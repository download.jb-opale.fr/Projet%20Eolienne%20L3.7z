ISO-10303-21;
HEADER;
FILE_DESCRIPTION(('STEP AP214'),'2;1');
FILE_NAME('part.step','',(''),(''),'','','');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
ENDSEC;
DATA;
#1=APPLICATION_CONTEXT('core data for automotive mechanical design processes');
#2=APPLICATION_PROTOCOL_DEFINITION('international standard','automotive_design',2000,#1);
#3=PRODUCT_CONTEXT('',#1,'mechanical');
#4=PRODUCT('Part','Part','',(#3));
#5=PRODUCT_RELATED_PRODUCT_CATEGORY('part','',(#4));
#6=PRODUCT_DEFINITION_FORMATION('','',#4);
#7=PRODUCT_DEFINITION_CONTEXT('part definition',#1,'design');
#8=PRODUCT_DEFINITION('design','',#6,#7);
#9=PRODUCT_DEFINITION_SHAPE('','',#8);
#10=(LENGTH_UNIT() NAMED_UNIT(*) SI_UNIT(.MILLI.,.METRE.));
#11=(NAMED_UNIT(*) PLANE_ANGLE_UNIT() SI_UNIT($,.RADIAN.));
#12=(NAMED_UNIT(*) SI_UNIT($,.STERADIAN.) SOLID_ANGLE_UNIT());
#13=UNCERTAINTY_MEASURE_WITH_UNIT(LENGTH_MEASURE(1.E-05),#10,'distance_accuracy_value','');
#14=(GEOMETRIC_REPRESENTATION_CONTEXT(3) GLOBAL_UNCERTAINTY_ASSIGNED_CONTEXT((#13)) GLOBAL_UNIT_ASSIGNED_CONTEXT((#10,
#11,#12)) REPRESENTATION_CONTEXT('',''));
#15=CARTESIAN_POINT('',(0.,0.,0.));
#16=DIRECTION('',(0.,0.,1.));
#17=DIRECTION('',(1.,0.,0.));
#18=AXIS2_PLACEMENT_3D('',#15,#16,#17);
#19=CARTESIAN_POINT('',(-41.6,0.,0.));
#20=DIRECTION('',(-1.,0.,0.));
#21=DIRECTION('',(0.,0.,1.));
#22=AXIS2_PLACEMENT_3D('',#19,#20,#21);
#23=PLANE('',#22);
#24=CARTESIAN_POINT('',(-41.6,0.,0.));
#25=DIRECTION('',(-1.,0.,0.));
#26=DIRECTION('',(0.,0.,1.));
#27=AXIS2_PLACEMENT_3D('',#24,#25,#26);
#28=CIRCLE('',#27,12.5);
#29=CARTESIAN_POINT('',(-41.6,0.,12.5));
#30=VERTEX_POINT('',#29);
#31=EDGE_CURVE('E363',#30,#30,#28,.T.);
#32=ORIENTED_EDGE('',*,*,#31,.T.);
#33=EDGE_LOOP('',(#32));
#34=FACE_BOUND('',#33,.T.);
#35=CARTESIAN_POINT('',(-41.6,0.,0.));
#36=DIRECTION('',(-1.,0.,0.));
#37=DIRECTION('',(0.,0.,1.));
#38=AXIS2_PLACEMENT_3D('',#35,#36,#37);
#39=CIRCLE('',#38,11.95);
#40=CARTESIAN_POINT('',(-41.6,0.,11.95));
#41=VERTEX_POINT('',#40);
#42=EDGE_CURVE('E354',#41,#41,#39,.T.);
#43=ORIENTED_EDGE('',*,*,#42,.F.);
#44=EDGE_LOOP('',(#43));
#45=FACE_BOUND('',#44,.T.);
#46=ADVANCED_FACE('F29',(#34,#45),#23,.T.);
#47=CARTESIAN_POINT('',(-33.7,0.,0.));
#48=DIRECTION('',(-1.,0.,0.));
#49=DIRECTION('',(0.,0.,1.));
#50=AXIS2_PLACEMENT_3D('',#47,#48,#49);
#51=PLANE('',#50);
#52=CARTESIAN_POINT('',(-33.7,0.,0.));
#53=DIRECTION('',(-1.,0.,0.));
#54=DIRECTION('',(0.,0.,1.));
#55=AXIS2_PLACEMENT_3D('',#52,#53,#54);
#56=CIRCLE('',#55,17.);
#57=CARTESIAN_POINT('',(-33.7,0.,17.));
#58=VERTEX_POINT('',#57);
#59=EDGE_CURVE('E369',#58,#58,#56,.T.);
#60=ORIENTED_EDGE('',*,*,#59,.T.);
#61=EDGE_LOOP('',(#60));
#62=FACE_BOUND('',#61,.T.);
#63=CARTESIAN_POINT('',(-33.7,0.,0.));
#64=DIRECTION('',(-1.,0.,0.));
#65=DIRECTION('',(0.,0.,1.));
#66=AXIS2_PLACEMENT_3D('',#63,#64,#65);
#67=CIRCLE('',#66,12.5);
#68=CARTESIAN_POINT('',(-33.7,0.,12.5));
#69=VERTEX_POINT('',#68);
#70=EDGE_CURVE('E360',#69,#69,#67,.T.);
#71=ORIENTED_EDGE('',*,*,#70,.F.);
#72=EDGE_LOOP('',(#71));
#73=FACE_BOUND('',#72,.T.);
#74=ADVANCED_FACE('F686',(#62,#73),#51,.T.);
#75=CARTESIAN_POINT('',(-14.2,0.,0.));
#76=DIRECTION('',(-1.,0.,0.));
#77=DIRECTION('',(0.,0.,1.));
#78=AXIS2_PLACEMENT_3D('',#75,#76,#77);
#79=PLANE('',#78);
#80=CARTESIAN_POINT('',(-14.2,0.,0.));
#81=DIRECTION('',(-1.,0.,0.));
#82=DIRECTION('',(0.,0.,1.));
#83=AXIS2_PLACEMENT_3D('',#80,#81,#82);
#84=CIRCLE('',#83,15.);
#85=CARTESIAN_POINT('',(-14.2,0.,15.));
#86=VERTEX_POINT('',#85);
#87=EDGE_CURVE('E387',#86,#86,#84,.T.);
#88=ORIENTED_EDGE('',*,*,#87,.T.);
#89=EDGE_LOOP('',(#88));
#90=FACE_BOUND('',#89,.T.);
#91=CARTESIAN_POINT('',(-14.2,0.,0.));
#92=DIRECTION('',(-1.,0.,0.));
#93=DIRECTION('',(0.,0.,1.));
#94=AXIS2_PLACEMENT_3D('',#91,#92,#93);
#95=CIRCLE('',#94,14.3);
#96=CARTESIAN_POINT('',(-14.2,0.,14.3));
#97=VERTEX_POINT('',#96);
#98=EDGE_CURVE('E378',#97,#97,#95,.T.);
#99=ORIENTED_EDGE('',*,*,#98,.F.);
#100=EDGE_LOOP('',(#99));
#101=FACE_BOUND('',#100,.T.);
#102=ADVANCED_FACE('F694',(#90,#101),#79,.T.);
#103=CARTESIAN_POINT('',(-2.,0.,0.));
#104=DIRECTION('',(-1.,0.,0.));
#105=DIRECTION('',(0.,0.,1.));
#106=AXIS2_PLACEMENT_3D('',#103,#104,#105);
#107=PLANE('',#106);
#108=CARTESIAN_POINT('',(-2.,0.,0.));
#109=DIRECTION('',(-1.,0.,0.));
#110=DIRECTION('',(0.,0.,1.));
#111=AXIS2_PLACEMENT_3D('',#108,#109,#110);
#112=CIRCLE('',#111,12.5);
#113=CARTESIAN_POINT('',(-2.,0.,12.5));
#114=VERTEX_POINT('',#113);
#115=EDGE_CURVE('E405',#114,#114,#112,.T.);
#116=ORIENTED_EDGE('',*,*,#115,.T.);
#117=EDGE_LOOP('',(#116));
#118=FACE_BOUND('',#117,.T.);
#119=CARTESIAN_POINT('',(-2.,0.,0.));
#120=DIRECTION('',(-1.,0.,0.));
#121=DIRECTION('',(0.,0.,1.));
#122=AXIS2_PLACEMENT_3D('',#119,#120,#121);
#123=CIRCLE('',#122,11.95);
#124=CARTESIAN_POINT('',(-2.,0.,11.95));
#125=VERTEX_POINT('',#124);
#126=EDGE_CURVE('E396',#125,#125,#123,.T.);
#127=ORIENTED_EDGE('',*,*,#126,.F.);
#128=EDGE_LOOP('',(#127));
#129=FACE_BOUND('',#128,.T.);
#130=ADVANCED_FACE('F728',(#118,#129),#107,.T.);
#131=CARTESIAN_POINT('',(16.,0.,0.));
#132=DIRECTION('',(-1.,0.,0.));
#133=DIRECTION('',(0.,0.,1.));
#134=AXIS2_PLACEMENT_3D('',#131,#132,#133);
#135=PLANE('',#134);
#136=CARTESIAN_POINT('',(16.,2.46642274315238,9.06746828136984));
#137=DIRECTION('',(-1.,0.,0.));
#138=DIRECTION('',(0.,0.951056516295152,0.309016994374952));
#139=AXIS2_PLACEMENT_3D('',#136,#137,#138);
#140=CIRCLE('',#139,4.);
#141=CARTESIAN_POINT('',(16.,-1.1725414088933,7.40676364172845));
#142=VERTEX_POINT('',#141);
#143=CARTESIAN_POINT('',(16.,-0.256880000774189,11.9972502126613));
#144=VERTEX_POINT('',#143);
#145=EDGE_CURVE('E541',#142,#144,#140,.T.);
#146=ORIENTED_EDGE('',*,*,#145,.F.);
#147=CARTESIAN_POINT('',(16.,0.,0.));
#148=DIRECTION('',(-1.,0.,0.));
#149=DIRECTION('',(0.,0.951056516295152,0.309016994374952));
#150=AXIS2_PLACEMENT_3D('',#147,#148,#149);
#151=CIRCLE('',#150,7.499);
#152=CARTESIAN_POINT('',(16.,-3.4049805094211,6.68140020732648));
#153=VERTEX_POINT('',#152);
#154=EDGE_CURVE('E545',#153,#142,#151,.T.);
#155=ORIENTED_EDGE('',*,*,#154,.F.);
#156=CARTESIAN_POINT('',(16.,-7.32510204594217,5.88600902124022));
#157=DIRECTION('',(-1.,0.,0.));
#158=DIRECTION('',(0.,0.951056516295152,0.309016994374952));
#159=AXIS2_PLACEMENT_3D('',#156,#157,#158);
#160=CIRCLE('',#159,4.);
#161=CARTESIAN_POINT('',(16.,-6.84398645692378,9.85696958387535));
#162=VERTEX_POINT('',#161);
#163=EDGE_CURVE('E543',#162,#153,#160,.T.);
#164=ORIENTED_EDGE('',*,*,#163,.F.);
#165=CARTESIAN_POINT('',(16.,0.,0.));
#166=DIRECTION('',(-1.,0.,0.));
#167=DIRECTION('',(0.,0.,1.));
#168=AXIS2_PLACEMENT_3D('',#165,#166,#167);
#169=CIRCLE('',#168,12.);
#170=CARTESIAN_POINT('',(16.,-7.25962702920644,9.55498903174751));
#171=VERTEX_POINT('',#170);
#172=EDGE_CURVE('E921',#171,#162,#169,.T.);
#173=ORIENTED_EDGE('',*,*,#172,.F.);
#174=CARTESIAN_POINT('',(16.,-3.33434621689583,8.78546284992771));
#175=DIRECTION('',(-1.,0.,0.));
#176=DIRECTION('',(0.,0.587785252292469,0.809016994374951));
#177=AXIS2_PLACEMENT_3D('',#174,#175,#176);
#178=CIRCLE('',#177,4.);
#179=CARTESIAN_POINT('',(16.,-5.30219236222711,5.30299511162706));
#180=VERTEX_POINT('',#179);
#181=EDGE_CURVE('E519',#180,#171,#178,.T.);
#182=ORIENTED_EDGE('',*,*,#181,.F.);
#183=CARTESIAN_POINT('',(16.,0.,0.));
#184=DIRECTION('',(-1.,0.,0.));
#185=DIRECTION('',(0.,0.587785252292469,0.809016994374951));
#186=AXIS2_PLACEMENT_3D('',#183,#184,#185);
#187=CIRCLE('',#186,7.499);
#188=CARTESIAN_POINT('',(16.,-6.68191560416752,3.40396898616638));
#189=VERTEX_POINT('',#188);
#190=EDGE_CURVE('E523',#189,#180,#187,.T.);
#191=ORIENTED_EDGE('',*,*,#190,.F.);
#192=CARTESIAN_POINT('',(16.,-9.38584133824337,0.456294373085347));
#193=DIRECTION('',(-1.,0.,0.));
#194=DIRECTION('',(0.,0.587785252292469,0.809016994374951));
#195=AXIS2_PLACEMENT_3D('',#192,#193,#194);
#196=CIRCLE('',#195,4.);
#197=CARTESIAN_POINT('',(16.,-11.3306827066207,3.95166160012288));
#198=VERTEX_POINT('',#197);
#199=EDGE_CURVE('E521',#198,#189,#196,.T.);
#200=ORIENTED_EDGE('',*,*,#199,.F.);
#201=CARTESIAN_POINT('',(16.,-11.4894432781293,3.46304680283858));
#202=VERTEX_POINT('',#201);
#203=EDGE_CURVE('E916',#202,#198,#169,.T.);
#204=ORIENTED_EDGE('',*,*,#203,.F.);
#205=CARTESIAN_POINT('',(16.,-7.86150825234946,5.14770921671269));
#206=DIRECTION('',(-1.,0.,0.));
#207=DIRECTION('',(0.,0.,1.));
#208=AXIS2_PLACEMENT_3D('',#205,#206,#207);
#209=CIRCLE('',#208,4.);
#210=CARTESIAN_POINT('',(16.,-7.40658604808024,1.17366269105867));
#211=VERTEX_POINT('',#210);
#212=EDGE_CURVE('E497',#211,#202,#209,.T.);
#213=ORIENTED_EDGE('',*,*,#212,.F.);
#214=CARTESIAN_POINT('',(16.,0.,0.));
#215=DIRECTION('',(-1.,0.,0.));
#216=DIRECTION('',(0.,0.,1.));
#217=AXIS2_PLACEMENT_3D('',#214,#215,#216);
#218=CIRCLE('',#217,7.499);
#219=CARTESIAN_POINT('',(16.,-7.40658604808023,-1.17366269105877));
#220=VERTEX_POINT('',#219);
#221=EDGE_CURVE('E501',#220,#211,#218,.T.);
#222=ORIENTED_EDGE('',*,*,#221,.F.);
#223=CARTESIAN_POINT('',(16.,-7.86150825234939,-5.1477092167128));
#224=DIRECTION('',(-1.,0.,0.));
#225=DIRECTION('',(0.,0.,1.));
#226=AXIS2_PLACEMENT_3D('',#223,#224,#225);
#227=CIRCLE('',#226,4.);
#228=CARTESIAN_POINT('',(16.,-11.4894432781292,-3.46304680283874));
#229=VERTEX_POINT('',#228);
#230=EDGE_CURVE('E499',#229,#220,#227,.T.);
#231=ORIENTED_EDGE('',*,*,#230,.F.);
#232=CARTESIAN_POINT('',(16.,-11.3306827066207,-3.95166160012305));
#233=VERTEX_POINT('',#232);
#234=EDGE_CURVE('E911',#233,#229,#169,.T.);
#235=ORIENTED_EDGE('',*,*,#234,.F.);
#236=CARTESIAN_POINT('',(16.,-9.38584133824337,-0.456294373085482));
#237=DIRECTION('',(-1.,0.,0.));
#238=DIRECTION('',(0.,-0.58778525229248,0.809016994374942));
#239=AXIS2_PLACEMENT_3D('',#236,#237,#238);
#240=CIRCLE('',#239,4.);
#241=CARTESIAN_POINT('',(16.,-6.68191560416748,-3.40396898616647));
#242=VERTEX_POINT('',#241);
#243=EDGE_CURVE('E475',#242,#233,#240,.T.);
#244=ORIENTED_EDGE('',*,*,#243,.F.);
#245=CARTESIAN_POINT('',(16.,0.,0.));
#246=DIRECTION('',(-1.,0.,0.));
#247=DIRECTION('',(0.,-0.58778525229248,0.809016994374942));
#248=AXIS2_PLACEMENT_3D('',#245,#246,#247);
#249=CIRCLE('',#248,7.499);
#250=CARTESIAN_POINT('',(16.,-5.30219236222703,-5.30299511162714));
#251=VERTEX_POINT('',#250);
#252=EDGE_CURVE('E479',#251,#242,#249,.T.);
#253=ORIENTED_EDGE('',*,*,#252,.F.);
#254=CARTESIAN_POINT('',(16.,-3.33434621689571,-8.78546284992776));
#255=DIRECTION('',(-1.,0.,0.));
#256=DIRECTION('',(0.,-0.58778525229248,0.809016994374942));
#257=AXIS2_PLACEMENT_3D('',#254,#255,#256);
#258=CIRCLE('',#257,4.);
#259=CARTESIAN_POINT('',(16.,-7.2596270292063,-9.55498903174761));
#260=VERTEX_POINT('',#259);
#261=EDGE_CURVE('E477',#260,#251,#258,.T.);
#262=ORIENTED_EDGE('',*,*,#261,.F.);
#263=CARTESIAN_POINT('',(16.,-6.84398645692364,-9.85696958387544));
#264=VERTEX_POINT('',#263);
#265=EDGE_CURVE('E906',#264,#260,#169,.T.);
#266=ORIENTED_EDGE('',*,*,#265,.F.);
#267=CARTESIAN_POINT('',(16.,-7.32510204594209,-5.88600902124032));
#268=DIRECTION('',(-1.,0.,0.));
#269=DIRECTION('',(0.,-0.951056516295156,0.309016994374938));
#270=AXIS2_PLACEMENT_3D('',#267,#268,#269);
#271=CIRCLE('',#270,4.);
#272=CARTESIAN_POINT('',(16.,-3.40498050942101,-6.68140020732653));
#273=VERTEX_POINT('',#272);
#274=EDGE_CURVE('E453',#273,#264,#271,.T.);
#275=ORIENTED_EDGE('',*,*,#274,.F.);
#276=CARTESIAN_POINT('',(16.,0.,0.));
#277=DIRECTION('',(-1.,0.,0.));
#278=DIRECTION('',(0.,-0.951056516295156,0.309016994374938));
#279=AXIS2_PLACEMENT_3D('',#276,#277,#278);
#280=CIRCLE('',#279,7.499);
#281=CARTESIAN_POINT('',(16.,-1.1725414088932,-7.40676364172847));
#282=VERTEX_POINT('',#281);
#283=EDGE_CURVE('E457',#282,#273,#280,.T.);
#284=ORIENTED_EDGE('',*,*,#283,.F.);
#285=CARTESIAN_POINT('',(16.,2.4664227431525,-9.06746828136981));
#286=DIRECTION('',(-1.,0.,0.));
#287=DIRECTION('',(0.,-0.951056516295156,0.309016994374938));
#288=AXIS2_PLACEMENT_3D('',#285,#286,#287);
#289=CIRCLE('',#288,4.);
#290=CARTESIAN_POINT('',(16.,-0.256880000774018,-11.9972502126613));
#291=VERTEX_POINT('',#290);
#292=EDGE_CURVE('E455',#291,#282,#289,.T.);
#293=ORIENTED_EDGE('',*,*,#292,.F.);
#294=CARTESIAN_POINT('',(16.,0.256880000774271,-11.9972502126613));
#295=VERTEX_POINT('',#294);
#296=EDGE_CURVE('E905',#295,#291,#169,.T.);
#297=ORIENTED_EDGE('',*,*,#296,.F.);
#298=CARTESIAN_POINT('',(16.,-2.46642274315231,-9.06746828136986));
#299=DIRECTION('',(-1.,0.,0.));
#300=DIRECTION('',(0.,-0.95105651629515,-0.309016994374958));
#301=AXIS2_PLACEMENT_3D('',#298,#299,#300);
#302=CIRCLE('',#301,4.);
#303=CARTESIAN_POINT('',(16.,1.17254140889336,-7.40676364172844));
#304=VERTEX_POINT('',#303);
#305=EDGE_CURVE('E432',#304,#295,#302,.T.);
#306=ORIENTED_EDGE('',*,*,#305,.F.);
#307=CARTESIAN_POINT('',(16.,0.,0.));
#308=DIRECTION('',(-1.,0.,0.));
#309=DIRECTION('',(0.,-0.95105651629515,-0.309016994374958));
#310=AXIS2_PLACEMENT_3D('',#307,#308,#309);
#311=CIRCLE('',#310,7.499);
#312=CARTESIAN_POINT('',(16.,3.40498050942115,-6.68140020732646));
#313=VERTEX_POINT('',#312);
#314=EDGE_CURVE('E436',#313,#304,#311,.T.);
#315=ORIENTED_EDGE('',*,*,#314,.F.);
#316=CARTESIAN_POINT('',(16.,7.32510204594221,-5.88600902124017));
#317=DIRECTION('',(-1.,0.,0.));
#318=DIRECTION('',(0.,-0.95105651629515,-0.309016994374958));
#319=AXIS2_PLACEMENT_3D('',#316,#317,#318);
#320=CIRCLE('',#319,4.);
#321=CARTESIAN_POINT('',(16.,6.84398645692385,-9.8569695838753));
#322=VERTEX_POINT('',#321);
#323=EDGE_CURVE('E434',#322,#313,#320,.T.);
#324=ORIENTED_EDGE('',*,*,#323,.F.);
#325=CARTESIAN_POINT('',(16.,7.25962702920651,-9.55498903174745));
#326=VERTEX_POINT('',#325);
#327=EDGE_CURVE('E633',#326,#322,#169,.T.);
#328=ORIENTED_EDGE('',*,*,#327,.F.);
#329=CARTESIAN_POINT('',(16.,3.3343462168959,-8.78546284992768));
#330=DIRECTION('',(-1.,0.,0.));
#331=DIRECTION('',(0.,-0.587785252292462,-0.809016994374955));
#332=AXIS2_PLACEMENT_3D('',#329,#330,#331);
#333=CIRCLE('',#332,4.);
#334=CARTESIAN_POINT('',(16.,5.30219236222715,-5.30299511162702));
#335=VERTEX_POINT('',#334);
#336=EDGE_CURVE('E414',#335,#326,#333,.T.);
#337=ORIENTED_EDGE('',*,*,#336,.F.);
#338=CARTESIAN_POINT('',(16.,0.,0.));
#339=DIRECTION('',(-1.,0.,0.));
#340=DIRECTION('',(0.,-0.587785252292462,-0.809016994374955));
#341=AXIS2_PLACEMENT_3D('',#338,#339,#340);
#342=CIRCLE('',#341,7.499);
#343=CARTESIAN_POINT('',(16.,6.68191560416755,-3.40396898616632));
#344=VERTEX_POINT('',#343);
#345=EDGE_CURVE('E418',#344,#335,#342,.T.);
#346=ORIENTED_EDGE('',*,*,#345,.F.);
#347=CARTESIAN_POINT('',(16.,9.38584133824337,-0.456294373085277));
#348=DIRECTION('',(-1.,0.,0.));
#349=DIRECTION('',(0.,-0.587785252292462,-0.809016994374955));
#350=AXIS2_PLACEMENT_3D('',#347,#348,#349);
#351=CIRCLE('',#350,4.);
#352=CARTESIAN_POINT('',(16.,11.3306827066208,-3.9516616001228));
#353=VERTEX_POINT('',#352);
#354=EDGE_CURVE('E416',#353,#344,#351,.T.);
#355=ORIENTED_EDGE('',*,*,#354,.F.);
#356=CARTESIAN_POINT('',(16.,11.4894432781292,-3.46304680283866));
#357=VERTEX_POINT('',#356);
#358=EDGE_CURVE('E629',#357,#353,#169,.T.);
#359=ORIENTED_EDGE('',*,*,#358,.F.);
#360=CARTESIAN_POINT('',(16.,7.86150825234942,-5.14770921671275));
#361=DIRECTION('',(-1.,0.,0.));
#362=DIRECTION('',(0.,0.,-1.));
#363=AXIS2_PLACEMENT_3D('',#360,#361,#362);
#364=CIRCLE('',#363,4.);
#365=CARTESIAN_POINT('',(16.,7.40658604808023,-1.17366269105872));
#366=VERTEX_POINT('',#365);
#367=EDGE_CURVE('E607',#366,#357,#364,.T.);
#368=ORIENTED_EDGE('',*,*,#367,.F.);
#369=CARTESIAN_POINT('',(16.,0.,0.));
#370=DIRECTION('',(-1.,0.,0.));
#371=DIRECTION('',(0.,0.,-1.));
#372=AXIS2_PLACEMENT_3D('',#369,#370,#371);
#373=CIRCLE('',#372,7.499);
#374=CARTESIAN_POINT('',(16.,7.40658604808023,1.17366269105872));
#375=VERTEX_POINT('',#374);
#376=EDGE_CURVE('E611',#375,#366,#373,.T.);
#377=ORIENTED_EDGE('',*,*,#376,.F.);
#378=CARTESIAN_POINT('',(16.,7.86150825234942,5.14770921671275));
#379=DIRECTION('',(-1.,0.,0.));
#380=DIRECTION('',(0.,0.,-1.));
#381=AXIS2_PLACEMENT_3D('',#378,#379,#380);
#382=CIRCLE('',#381,4.);
#383=CARTESIAN_POINT('',(16.,11.4894432781292,3.46304680283866));
#384=VERTEX_POINT('',#383);
#385=EDGE_CURVE('E609',#384,#375,#382,.T.);
#386=ORIENTED_EDGE('',*,*,#385,.F.);
#387=CARTESIAN_POINT('',(16.,11.3306827066207,3.95166160012296));
#388=VERTEX_POINT('',#387);
#389=EDGE_CURVE('E627',#388,#384,#169,.T.);
#390=ORIENTED_EDGE('',*,*,#389,.F.);
#391=CARTESIAN_POINT('',(16.,9.38584133824337,0.456294373085413));
#392=DIRECTION('',(-1.,0.,0.));
#393=DIRECTION('',(0.,0.587785252292474,-0.809016994374947));
#394=AXIS2_PLACEMENT_3D('',#391,#392,#393);
#395=CIRCLE('',#394,4.);
#396=CARTESIAN_POINT('',(16.,6.6819156041675,3.40396898616642));
#397=VERTEX_POINT('',#396);
#398=EDGE_CURVE('E585',#397,#388,#395,.T.);
#399=ORIENTED_EDGE('',*,*,#398,.F.);
#400=CARTESIAN_POINT('',(16.,0.,0.));
#401=DIRECTION('',(-1.,0.,0.));
#402=DIRECTION('',(0.,0.587785252292474,-0.809016994374947));
#403=AXIS2_PLACEMENT_3D('',#400,#401,#402);
#404=CIRCLE('',#403,7.499);
#405=CARTESIAN_POINT('',(16.,5.30219236222707,5.3029951116271));
#406=VERTEX_POINT('',#405);
#407=EDGE_CURVE('E589',#406,#397,#404,.T.);
#408=ORIENTED_EDGE('',*,*,#407,.F.);
#409=CARTESIAN_POINT('',(16.,3.33434621689577,8.78546284992773));
#410=DIRECTION('',(-1.,0.,0.));
#411=DIRECTION('',(0.,0.587785252292474,-0.809016994374947));
#412=AXIS2_PLACEMENT_3D('',#409,#410,#411);
#413=CIRCLE('',#412,4.);
#414=CARTESIAN_POINT('',(16.,7.25962702920638,9.55498903174756));
#415=VERTEX_POINT('',#414);
#416=EDGE_CURVE('E587',#415,#406,#413,.T.);
#417=ORIENTED_EDGE('',*,*,#416,.F.);
#418=CARTESIAN_POINT('',(16.,6.84398645692371,9.8569695838754));
#419=VERTEX_POINT('',#418);
#420=EDGE_CURVE('E931',#419,#415,#169,.T.);
#421=ORIENTED_EDGE('',*,*,#420,.F.);
#422=CARTESIAN_POINT('',(16.,7.32510204594213,5.88600902124027));
#423=DIRECTION('',(-1.,0.,0.));
#424=DIRECTION('',(0.,0.951056516295155,-0.309016994374945));
#425=AXIS2_PLACEMENT_3D('',#422,#423,#424);
#426=CIRCLE('',#425,4.);
#427=CARTESIAN_POINT('',(16.,3.40498050942106,6.68140020732651));
#428=VERTEX_POINT('',#427);
#429=EDGE_CURVE('E563',#428,#419,#426,.T.);
#430=ORIENTED_EDGE('',*,*,#429,.F.);
#431=CARTESIAN_POINT('',(16.,0.,0.));
#432=DIRECTION('',(-1.,0.,0.));
#433=DIRECTION('',(0.,0.951056516295155,-0.309016994374945));
#434=AXIS2_PLACEMENT_3D('',#431,#432,#433);
#435=CIRCLE('',#434,7.499);
#436=CARTESIAN_POINT('',(16.,1.17254140889325,7.40676364172846));
#437=VERTEX_POINT('',#436);
#438=EDGE_CURVE('E567',#437,#428,#435,.T.);
#439=ORIENTED_EDGE('',*,*,#438,.F.);
#440=CARTESIAN_POINT('',(16.,-2.46642274315244,9.06746828136982));
#441=DIRECTION('',(-1.,0.,0.));
#442=DIRECTION('',(0.,0.951056516295155,-0.309016994374945));
#443=AXIS2_PLACEMENT_3D('',#440,#441,#442);
#444=CIRCLE('',#443,4.);
#445=CARTESIAN_POINT('',(16.,0.2568800007741,11.9972502126613));
#446=VERTEX_POINT('',#445);
#447=EDGE_CURVE('E565',#446,#437,#444,.T.);
#448=ORIENTED_EDGE('',*,*,#447,.F.);
#449=EDGE_CURVE('E926',#144,#446,#169,.T.);
#450=ORIENTED_EDGE('',*,*,#449,.F.);
#451=EDGE_LOOP('',(#146,#155,#164,#173,#182,#191,#200,#204,#213,#222,#231,#235,#244,#253,#262,
#266,#275,#284,#293,#297,#306,#315,#324,#328,#337,#346,#355,#359,#368,#377,#386,#390,#399,#408,
#417,#421,#430,#439,#448,#450));
#452=FACE_BOUND('',#451,.T.);
#453=ADVANCED_FACE('F31',(#452),#135,.F.);
#454=CARTESIAN_POINT('',(-10.,0.,0.));
#455=DIRECTION('',(-1.,0.,0.));
#456=DIRECTION('',(0.,0.,1.));
#457=AXIS2_PLACEMENT_3D('',#454,#455,#456);
#458=CYLINDRICAL_SURFACE('',#457,12.);
#459=DIRECTION('',(-1.,0.,0.));
#460=VECTOR('',#459,1.);
#461=CARTESIAN_POINT('',(8.,7.25962702920651,-9.55498903174744));
#462=LINE('',#461,#460);
#463=CARTESIAN_POINT('',(0.,7.25962702920652,-9.55498903174745));
#464=VERTEX_POINT('',#463);
#465=EDGE_CURVE('E426',#326,#464,#462,.T.);
#466=ORIENTED_EDGE('',*,*,#465,.F.);
#467=ORIENTED_EDGE('',*,*,#327,.T.);
#468=DIRECTION('',(-1.,0.,0.));
#469=VECTOR('',#468,1.);
#470=CARTESIAN_POINT('',(8.,6.84398645692385,-9.8569695838753));
#471=LINE('',#470,#469);
#472=CARTESIAN_POINT('',(0.,6.84398645692385,-9.8569695838753));
#473=VERTEX_POINT('',#472);
#474=EDGE_CURVE('E442',#473,#322,#471,.F.);
#475=ORIENTED_EDGE('',*,*,#474,.F.);
#476=CARTESIAN_POINT('',(0.,0.,0.));
#477=DIRECTION('',(-1.,0.,0.));
#478=DIRECTION('',(0.,0.,1.));
#479=AXIS2_PLACEMENT_3D('',#476,#477,#478);
#480=CIRCLE('',#479,12.);
#481=EDGE_CURVE('E628',#464,#473,#480,.T.);
#482=ORIENTED_EDGE('',*,*,#481,.F.);
#483=EDGE_LOOP('',(#466,#467,#475,#482));
#484=FACE_BOUND('',#483,.T.);
#485=ADVANCED_FACE('F877',(#484),#458,.T.);
#486=DIRECTION('',(-1.,0.,0.));
#487=VECTOR('',#486,1.);
#488=CARTESIAN_POINT('',(8.,11.3306827066208,-3.9516616001228));
#489=LINE('',#488,#487);
#490=CARTESIAN_POINT('',(0.,11.3306827066208,-3.9516616001228));
#491=VERTEX_POINT('',#490);
#492=EDGE_CURVE('E424',#491,#353,#489,.F.);
#493=ORIENTED_EDGE('',*,*,#492,.F.);
#494=CARTESIAN_POINT('',(0.,11.4894432781292,-3.46304680283865));
#495=VERTEX_POINT('',#494);
#496=EDGE_CURVE('E624',#495,#491,#480,.T.);
#497=ORIENTED_EDGE('',*,*,#496,.F.);
#498=DIRECTION('',(-1.,0.,0.));
#499=VECTOR('',#498,1.);
#500=CARTESIAN_POINT('',(8.,11.4894432781292,-3.46304680283865));
#501=LINE('',#500,#499);
#502=EDGE_CURVE('E621',#357,#495,#501,.T.);
#503=ORIENTED_EDGE('',*,*,#502,.F.);
#504=ORIENTED_EDGE('',*,*,#358,.T.);
#505=EDGE_LOOP('',(#493,#497,#503,#504));
#506=FACE_BOUND('',#505,.T.);
#507=ADVANCED_FACE('F885',(#506),#458,.T.);
#508=DIRECTION('',(-1.,0.,0.));
#509=VECTOR('',#508,1.);
#510=CARTESIAN_POINT('',(8.,0.256880000774273,-11.9972502126613));
#511=LINE('',#510,#509);
#512=CARTESIAN_POINT('',(0.,0.256880000774273,-11.9972502126613));
#513=VERTEX_POINT('',#512);
#514=EDGE_CURVE('E445',#295,#513,#511,.T.);
#515=ORIENTED_EDGE('',*,*,#514,.F.);
#516=ORIENTED_EDGE('',*,*,#296,.T.);
#517=DIRECTION('',(-1.,0.,0.));
#518=VECTOR('',#517,1.);
#519=CARTESIAN_POINT('',(8.,-0.256880000774022,-11.9972502126613));
#520=LINE('',#519,#518);
#521=CARTESIAN_POINT('',(0.,-0.256880000774022,-11.9972502126613));
#522=VERTEX_POINT('',#521);
#523=EDGE_CURVE('E464',#522,#291,#520,.F.);
#524=ORIENTED_EDGE('',*,*,#523,.F.);
#525=EDGE_CURVE('E978',#513,#522,#480,.T.);
#526=ORIENTED_EDGE('',*,*,#525,.F.);
#527=EDGE_LOOP('',(#515,#516,#524,#526));
#528=FACE_BOUND('',#527,.T.);
#529=ADVANCED_FACE('F890',(#528),#458,.T.);
#530=DIRECTION('',(-1.,0.,0.));
#531=VECTOR('',#530,1.);
#532=CARTESIAN_POINT('',(8.,-6.84398645692364,-9.85696958387544));
#533=LINE('',#532,#531);
#534=CARTESIAN_POINT('',(0.,-6.84398645692364,-9.85696958387544));
#535=VERTEX_POINT('',#534);
#536=EDGE_CURVE('E467',#264,#535,#533,.T.);
#537=ORIENTED_EDGE('',*,*,#536,.F.);
#538=ORIENTED_EDGE('',*,*,#265,.T.);
#539=DIRECTION('',(-1.,0.,0.));
#540=VECTOR('',#539,1.);
#541=CARTESIAN_POINT('',(8.,-7.2596270292063,-9.55498903174761));
#542=LINE('',#541,#540);
#543=CARTESIAN_POINT('',(0.,-7.2596270292063,-9.55498903174761));
#544=VERTEX_POINT('',#543);
#545=EDGE_CURVE('E486',#544,#260,#542,.F.);
#546=ORIENTED_EDGE('',*,*,#545,.F.);
#547=EDGE_CURVE('E974',#535,#544,#480,.T.);
#548=ORIENTED_EDGE('',*,*,#547,.F.);
#549=EDGE_LOOP('',(#537,#538,#546,#548));
#550=FACE_BOUND('',#549,.T.);
#551=ADVANCED_FACE('F1000',(#550),#458,.T.);
#552=DIRECTION('',(-1.,0.,0.));
#553=VECTOR('',#552,1.);
#554=CARTESIAN_POINT('',(8.,-11.3306827066207,-3.95166160012305));
#555=LINE('',#554,#553);
#556=CARTESIAN_POINT('',(0.,-11.3306827066207,-3.95166160012305));
#557=VERTEX_POINT('',#556);
#558=EDGE_CURVE('E489',#233,#557,#555,.T.);
#559=ORIENTED_EDGE('',*,*,#558,.F.);
#560=ORIENTED_EDGE('',*,*,#234,.T.);
#561=DIRECTION('',(-1.,0.,0.));
#562=VECTOR('',#561,1.);
#563=CARTESIAN_POINT('',(8.,-11.4894432781292,-3.46304680283873));
#564=LINE('',#563,#562);
#565=CARTESIAN_POINT('',(0.,-11.4894432781292,-3.46304680283873));
#566=VERTEX_POINT('',#565);
#567=EDGE_CURVE('E508',#566,#229,#564,.F.);
#568=ORIENTED_EDGE('',*,*,#567,.F.);
#569=EDGE_CURVE('E970',#557,#566,#480,.T.);
#570=ORIENTED_EDGE('',*,*,#569,.F.);
#571=EDGE_LOOP('',(#559,#560,#568,#570));
#572=FACE_BOUND('',#571,.T.);
#573=ADVANCED_FACE('F1004',(#572),#458,.T.);
#574=DIRECTION('',(-1.,0.,0.));
#575=VECTOR('',#574,1.);
#576=CARTESIAN_POINT('',(8.,-11.4894432781292,3.46304680283857));
#577=LINE('',#576,#575);
#578=CARTESIAN_POINT('',(0.,-11.4894432781292,3.46304680283857));
#579=VERTEX_POINT('',#578);
#580=EDGE_CURVE('E511',#202,#579,#577,.T.);
#581=ORIENTED_EDGE('',*,*,#580,.F.);
#582=ORIENTED_EDGE('',*,*,#203,.T.);
#583=DIRECTION('',(-1.,0.,0.));
#584=VECTOR('',#583,1.);
#585=CARTESIAN_POINT('',(8.,-11.3306827066207,3.95166160012288));
#586=LINE('',#585,#584);
#587=CARTESIAN_POINT('',(0.,-11.3306827066207,3.95166160012288));
#588=VERTEX_POINT('',#587);
#589=EDGE_CURVE('E530',#588,#198,#586,.F.);
#590=ORIENTED_EDGE('',*,*,#589,.F.);
#591=EDGE_CURVE('E966',#579,#588,#480,.T.);
#592=ORIENTED_EDGE('',*,*,#591,.F.);
#593=EDGE_LOOP('',(#581,#582,#590,#592));
#594=FACE_BOUND('',#593,.T.);
#595=ADVANCED_FACE('F1008',(#594),#458,.T.);
#596=DIRECTION('',(-1.,0.,0.));
#597=VECTOR('',#596,1.);
#598=CARTESIAN_POINT('',(8.,-7.25962702920644,9.5549890317475));
#599=LINE('',#598,#597);
#600=CARTESIAN_POINT('',(0.,-7.25962702920644,9.5549890317475));
#601=VERTEX_POINT('',#600);
#602=EDGE_CURVE('E533',#171,#601,#599,.T.);
#603=ORIENTED_EDGE('',*,*,#602,.F.);
#604=ORIENTED_EDGE('',*,*,#172,.T.);
#605=DIRECTION('',(-1.,0.,0.));
#606=VECTOR('',#605,1.);
#607=CARTESIAN_POINT('',(8.,-6.84398645692378,9.85696958387535));
#608=LINE('',#607,#606);
#609=CARTESIAN_POINT('',(0.,-6.84398645692378,9.85696958387535));
#610=VERTEX_POINT('',#609);
#611=EDGE_CURVE('E552',#610,#162,#608,.F.);
#612=ORIENTED_EDGE('',*,*,#611,.F.);
#613=EDGE_CURVE('E962',#601,#610,#480,.T.);
#614=ORIENTED_EDGE('',*,*,#613,.F.);
#615=EDGE_LOOP('',(#603,#604,#612,#614));
#616=FACE_BOUND('',#615,.T.);
#617=ADVANCED_FACE('F1027',(#616),#458,.T.);
#618=DIRECTION('',(-1.,0.,0.));
#619=VECTOR('',#618,1.);
#620=CARTESIAN_POINT('',(8.,-0.256880000774188,11.9972502126613));
#621=LINE('',#620,#619);
#622=CARTESIAN_POINT('',(0.,-0.25688000077419,11.9972502126613));
#623=VERTEX_POINT('',#622);
#624=EDGE_CURVE('E555',#144,#623,#621,.T.);
#625=ORIENTED_EDGE('',*,*,#624,.F.);
#626=ORIENTED_EDGE('',*,*,#449,.T.);
#627=DIRECTION('',(-1.,0.,0.));
#628=VECTOR('',#627,1.);
#629=CARTESIAN_POINT('',(8.,0.256880000774104,11.9972502126613));
#630=LINE('',#629,#628);
#631=CARTESIAN_POINT('',(0.,0.256880000774103,11.9972502126613));
#632=VERTEX_POINT('',#631);
#633=EDGE_CURVE('E574',#632,#446,#630,.F.);
#634=ORIENTED_EDGE('',*,*,#633,.F.);
#635=EDGE_CURVE('E958',#623,#632,#480,.T.);
#636=ORIENTED_EDGE('',*,*,#635,.F.);
#637=EDGE_LOOP('',(#625,#626,#634,#636));
#638=FACE_BOUND('',#637,.T.);
#639=ADVANCED_FACE('F881',(#638),#458,.T.);
#640=DIRECTION('',(-1.,0.,0.));
#641=VECTOR('',#640,1.);
#642=CARTESIAN_POINT('',(8.,6.84398645692371,9.8569695838754));
#643=LINE('',#642,#641);
#644=CARTESIAN_POINT('',(0.,6.84398645692371,9.8569695838754));
#645=VERTEX_POINT('',#644);
#646=EDGE_CURVE('E577',#419,#645,#643,.T.);
#647=ORIENTED_EDGE('',*,*,#646,.F.);
#648=ORIENTED_EDGE('',*,*,#420,.T.);
#649=DIRECTION('',(-1.,0.,0.));
#650=VECTOR('',#649,1.);
#651=CARTESIAN_POINT('',(8.,7.25962702920638,9.55498903174756));
#652=LINE('',#651,#650);
#653=CARTESIAN_POINT('',(0.,7.25962702920638,9.55498903174756));
#654=VERTEX_POINT('',#653);
#655=EDGE_CURVE('E596',#654,#415,#652,.F.);
#656=ORIENTED_EDGE('',*,*,#655,.F.);
#657=EDGE_CURVE('E956',#645,#654,#480,.T.);
#658=ORIENTED_EDGE('',*,*,#657,.F.);
#659=EDGE_LOOP('',(#647,#648,#656,#658));
#660=FACE_BOUND('',#659,.T.);
#661=ADVANCED_FACE('F875',(#660),#458,.T.);
#662=DIRECTION('',(-1.,0.,0.));
#663=VECTOR('',#662,1.);
#664=CARTESIAN_POINT('',(8.,11.3306827066207,3.95166160012296));
#665=LINE('',#664,#663);
#666=CARTESIAN_POINT('',(0.,11.3306827066207,3.95166160012296));
#667=VERTEX_POINT('',#666);
#668=EDGE_CURVE('E599',#388,#667,#665,.T.);
#669=ORIENTED_EDGE('',*,*,#668,.F.);
#670=ORIENTED_EDGE('',*,*,#389,.T.);
#671=DIRECTION('',(-1.,0.,0.));
#672=VECTOR('',#671,1.);
#673=CARTESIAN_POINT('',(8.,11.4894432781292,3.46304680283865));
#674=LINE('',#673,#672);
#675=CARTESIAN_POINT('',(0.,11.4894432781292,3.46304680283865));
#676=VERTEX_POINT('',#675);
#677=EDGE_CURVE('E618',#676,#384,#674,.F.);
#678=ORIENTED_EDGE('',*,*,#677,.F.);
#679=EDGE_CURVE('E623',#667,#676,#480,.T.);
#680=ORIENTED_EDGE('',*,*,#679,.F.);
#681=EDGE_LOOP('',(#669,#670,#678,#680));
#682=FACE_BOUND('',#681,.T.);
#683=ADVANCED_FACE('F872',(#682),#458,.T.);
#684=CARTESIAN_POINT('',(16.,7.86150825234942,-5.14770921671275));
#685=DIRECTION('',(-1.,0.,0.));
#686=DIRECTION('',(0.,0.,1.));
#687=AXIS2_PLACEMENT_3D('',#684,#685,#686);
#688=CYLINDRICAL_SURFACE('',#687,4.);
#689=ORIENTED_EDGE('',*,*,#502,.T.);
#690=CARTESIAN_POINT('',(0.,7.86150825234942,-5.14770921671275));
#691=DIRECTION('',(-1.,0.,0.));
#692=DIRECTION('',(0.,0.,-1.));
#693=AXIS2_PLACEMENT_3D('',#690,#691,#692);
#694=CIRCLE('',#693,4.);
#695=CARTESIAN_POINT('',(0.,7.40658604808023,-1.17366269105872));
#696=VERTEX_POINT('',#695);
#697=EDGE_CURVE('E601',#696,#495,#694,.T.);
#698=ORIENTED_EDGE('',*,*,#697,.F.);
#699=DIRECTION('',(-1.,0.,0.));
#700=VECTOR('',#699,1.);
#701=CARTESIAN_POINT('',(16.,7.40658604808023,-1.17366269105872));
#702=LINE('',#701,#700);
#703=EDGE_CURVE('E613',#366,#696,#702,.T.);
#704=ORIENTED_EDGE('',*,*,#703,.F.);
#705=ORIENTED_EDGE('',*,*,#367,.T.);
#706=EDGE_LOOP('',(#689,#698,#704,#705));
#707=FACE_BOUND('',#706,.T.);
#708=ADVANCED_FACE('F869',(#707),#688,.T.);
#709=CARTESIAN_POINT('',(16.,7.86150825234942,5.14770921671275));
#710=DIRECTION('',(-1.,0.,0.));
#711=DIRECTION('',(0.,0.,1.));
#712=AXIS2_PLACEMENT_3D('',#709,#710,#711);
#713=CYLINDRICAL_SURFACE('',#712,4.);
#714=ORIENTED_EDGE('',*,*,#677,.T.);
#715=ORIENTED_EDGE('',*,*,#385,.T.);
#716=DIRECTION('',(-1.,0.,0.));
#717=VECTOR('',#716,1.);
#718=CARTESIAN_POINT('',(16.,7.40658604808023,1.17366269105872));
#719=LINE('',#718,#717);
#720=CARTESIAN_POINT('',(0.,7.40658604808023,1.17366269105872));
#721=VERTEX_POINT('',#720);
#722=EDGE_CURVE('E616',#375,#721,#719,.T.);
#723=ORIENTED_EDGE('',*,*,#722,.T.);
#724=CARTESIAN_POINT('',(0.,7.86150825234942,5.14770921671275));
#725=DIRECTION('',(1.,0.,0.));
#726=DIRECTION('',(0.,0.,-1.));
#727=AXIS2_PLACEMENT_3D('',#724,#725,#726);
#728=CIRCLE('',#727,4.);
#729=EDGE_CURVE('E632',#721,#676,#728,.T.);
#730=ORIENTED_EDGE('',*,*,#729,.T.);
#731=EDGE_LOOP('',(#714,#715,#723,#730));
#732=FACE_BOUND('',#731,.T.);
#733=ADVANCED_FACE('F865',(#732),#713,.T.);
#734=CARTESIAN_POINT('',(16.,0.,0.));
#735=DIRECTION('',(-1.,0.,0.));
#736=DIRECTION('',(0.,0.,1.));
#737=AXIS2_PLACEMENT_3D('',#734,#735,#736);
#738=CYLINDRICAL_SURFACE('',#737,7.499);
#739=CARTESIAN_POINT('',(0.,0.,0.));
#740=DIRECTION('',(-1.,0.,0.));
#741=DIRECTION('',(0.,0.,-1.));
#742=AXIS2_PLACEMENT_3D('',#739,#740,#741);
#743=CIRCLE('',#742,7.499);
#744=EDGE_CURVE('E604',#721,#696,#743,.T.);
#745=ORIENTED_EDGE('',*,*,#744,.F.);
#746=ORIENTED_EDGE('',*,*,#722,.F.);
#747=ORIENTED_EDGE('',*,*,#376,.T.);
#748=ORIENTED_EDGE('',*,*,#703,.T.);
#749=EDGE_LOOP('',(#745,#746,#747,#748));
#750=FACE_BOUND('',#749,.T.);
#751=ADVANCED_FACE('F861',(#750),#738,.T.);
#752=CARTESIAN_POINT('',(16.,9.38584133824337,0.456294373085413));
#753=DIRECTION('',(-1.,0.,0.));
#754=DIRECTION('',(0.,0.,1.));
#755=AXIS2_PLACEMENT_3D('',#752,#753,#754);
#756=CYLINDRICAL_SURFACE('',#755,4.);
#757=ORIENTED_EDGE('',*,*,#668,.T.);
#758=CARTESIAN_POINT('',(0.,9.38584133824337,0.456294373085413));
#759=DIRECTION('',(-1.,0.,0.));
#760=DIRECTION('',(0.,0.587785252292474,-0.809016994374947));
#761=AXIS2_PLACEMENT_3D('',#758,#759,#760);
#762=CIRCLE('',#761,4.);
#763=CARTESIAN_POINT('',(0.,6.6819156041675,3.40396898616642));
#764=VERTEX_POINT('',#763);
#765=EDGE_CURVE('E579',#764,#667,#762,.T.);
#766=ORIENTED_EDGE('',*,*,#765,.F.);
#767=DIRECTION('',(-1.,0.,0.));
#768=VECTOR('',#767,1.);
#769=CARTESIAN_POINT('',(16.,6.6819156041675,3.40396898616642));
#770=LINE('',#769,#768);
#771=EDGE_CURVE('E591',#397,#764,#770,.T.);
#772=ORIENTED_EDGE('',*,*,#771,.F.);
#773=ORIENTED_EDGE('',*,*,#398,.T.);
#774=EDGE_LOOP('',(#757,#766,#772,#773));
#775=FACE_BOUND('',#774,.T.);
#776=ADVANCED_FACE('F857',(#775),#756,.T.);
#777=CARTESIAN_POINT('',(16.,3.33434621689577,8.78546284992773));
#778=DIRECTION('',(-1.,0.,0.));
#779=DIRECTION('',(0.,0.,1.));
#780=AXIS2_PLACEMENT_3D('',#777,#778,#779);
#781=CYLINDRICAL_SURFACE('',#780,4.);
#782=ORIENTED_EDGE('',*,*,#655,.T.);
#783=ORIENTED_EDGE('',*,*,#416,.T.);
#784=DIRECTION('',(-1.,0.,0.));
#785=VECTOR('',#784,1.);
#786=CARTESIAN_POINT('',(16.,5.30219236222707,5.3029951116271));
#787=LINE('',#786,#785);
#788=CARTESIAN_POINT('',(0.,5.30219236222707,5.3029951116271));
#789=VERTEX_POINT('',#788);
#790=EDGE_CURVE('E594',#406,#789,#787,.T.);
#791=ORIENTED_EDGE('',*,*,#790,.T.);
#792=CARTESIAN_POINT('',(0.,3.33434621689577,8.78546284992773));
#793=DIRECTION('',(1.,0.,0.));
#794=DIRECTION('',(0.,0.,-1.));
#795=AXIS2_PLACEMENT_3D('',#792,#793,#794);
#796=CIRCLE('',#795,4.);
#797=EDGE_CURVE('E635',#789,#654,#796,.T.);
#798=ORIENTED_EDGE('',*,*,#797,.T.);
#799=EDGE_LOOP('',(#782,#783,#791,#798));
#800=FACE_BOUND('',#799,.T.);
#801=ADVANCED_FACE('F853',(#800),#781,.T.);
#802=CARTESIAN_POINT('',(16.,0.,0.));
#803=DIRECTION('',(-1.,0.,0.));
#804=DIRECTION('',(0.,0.,1.));
#805=AXIS2_PLACEMENT_3D('',#802,#803,#804);
#806=CYLINDRICAL_SURFACE('',#805,7.499);
#807=CARTESIAN_POINT('',(0.,0.,0.));
#808=DIRECTION('',(-1.,0.,0.));
#809=DIRECTION('',(0.,0.587785252292474,-0.809016994374947));
#810=AXIS2_PLACEMENT_3D('',#807,#808,#809);
#811=CIRCLE('',#810,7.499);
#812=EDGE_CURVE('E582',#789,#764,#811,.T.);
#813=ORIENTED_EDGE('',*,*,#812,.F.);
#814=ORIENTED_EDGE('',*,*,#790,.F.);
#815=ORIENTED_EDGE('',*,*,#407,.T.);
#816=ORIENTED_EDGE('',*,*,#771,.T.);
#817=EDGE_LOOP('',(#813,#814,#815,#816));
#818=FACE_BOUND('',#817,.T.);
#819=ADVANCED_FACE('F849',(#818),#806,.T.);
#820=CARTESIAN_POINT('',(16.,7.32510204594213,5.88600902124027));
#821=DIRECTION('',(-1.,0.,0.));
#822=DIRECTION('',(0.,0.,1.));
#823=AXIS2_PLACEMENT_3D('',#820,#821,#822);
#824=CYLINDRICAL_SURFACE('',#823,4.);
#825=ORIENTED_EDGE('',*,*,#646,.T.);
#826=CARTESIAN_POINT('',(0.,7.32510204594213,5.88600902124027));
#827=DIRECTION('',(-1.,0.,0.));
#828=DIRECTION('',(0.,0.951056516295155,-0.309016994374945));
#829=AXIS2_PLACEMENT_3D('',#826,#827,#828);
#830=CIRCLE('',#829,4.);
#831=CARTESIAN_POINT('',(0.,3.40498050942106,6.68140020732651));
#832=VERTEX_POINT('',#831);
#833=EDGE_CURVE('E557',#832,#645,#830,.T.);
#834=ORIENTED_EDGE('',*,*,#833,.F.);
#835=DIRECTION('',(-1.,0.,0.));
#836=VECTOR('',#835,1.);
#837=CARTESIAN_POINT('',(16.,3.40498050942106,6.68140020732651));
#838=LINE('',#837,#836);
#839=EDGE_CURVE('E569',#428,#832,#838,.T.);
#840=ORIENTED_EDGE('',*,*,#839,.F.);
#841=ORIENTED_EDGE('',*,*,#429,.T.);
#842=EDGE_LOOP('',(#825,#834,#840,#841));
#843=FACE_BOUND('',#842,.T.);
#844=ADVANCED_FACE('F845',(#843),#824,.T.);
#845=CARTESIAN_POINT('',(16.,-2.46642274315244,9.06746828136982));
#846=DIRECTION('',(-1.,0.,0.));
#847=DIRECTION('',(0.,0.,1.));
#848=AXIS2_PLACEMENT_3D('',#845,#846,#847);
#849=CYLINDRICAL_SURFACE('',#848,4.);
#850=ORIENTED_EDGE('',*,*,#633,.T.);
#851=ORIENTED_EDGE('',*,*,#447,.T.);
#852=DIRECTION('',(-1.,0.,0.));
#853=VECTOR('',#852,1.);
#854=CARTESIAN_POINT('',(16.,1.17254140889325,7.40676364172846));
#855=LINE('',#854,#853);
#856=CARTESIAN_POINT('',(0.,1.17254140889325,7.40676364172846));
#857=VERTEX_POINT('',#856);
#858=EDGE_CURVE('E572',#437,#857,#855,.T.);
#859=ORIENTED_EDGE('',*,*,#858,.T.);
#860=CARTESIAN_POINT('',(0.,-2.46642274315244,9.06746828136982));
#861=DIRECTION('',(1.,0.,0.));
#862=DIRECTION('',(0.,0.,-1.));
#863=AXIS2_PLACEMENT_3D('',#860,#861,#862);
#864=CIRCLE('',#863,4.);
#865=EDGE_CURVE('E637',#857,#632,#864,.T.);
#866=ORIENTED_EDGE('',*,*,#865,.T.);
#867=EDGE_LOOP('',(#850,#851,#859,#866));
#868=FACE_BOUND('',#867,.T.);
#869=ADVANCED_FACE('F841',(#868),#849,.T.);
#870=CARTESIAN_POINT('',(16.,0.,0.));
#871=DIRECTION('',(-1.,0.,0.));
#872=DIRECTION('',(0.,0.,1.));
#873=AXIS2_PLACEMENT_3D('',#870,#871,#872);
#874=CYLINDRICAL_SURFACE('',#873,7.499);
#875=CARTESIAN_POINT('',(0.,0.,0.));
#876=DIRECTION('',(-1.,0.,0.));
#877=DIRECTION('',(0.,0.951056516295155,-0.309016994374945));
#878=AXIS2_PLACEMENT_3D('',#875,#876,#877);
#879=CIRCLE('',#878,7.499);
#880=EDGE_CURVE('E560',#857,#832,#879,.T.);
#881=ORIENTED_EDGE('',*,*,#880,.F.);
#882=ORIENTED_EDGE('',*,*,#858,.F.);
#883=ORIENTED_EDGE('',*,*,#438,.T.);
#884=ORIENTED_EDGE('',*,*,#839,.T.);
#885=EDGE_LOOP('',(#881,#882,#883,#884));
#886=FACE_BOUND('',#885,.T.);
#887=ADVANCED_FACE('F837',(#886),#874,.T.);
#888=CARTESIAN_POINT('',(16.,2.46642274315238,9.06746828136984));
#889=DIRECTION('',(-1.,0.,0.));
#890=DIRECTION('',(0.,0.,1.));
#891=AXIS2_PLACEMENT_3D('',#888,#889,#890);
#892=CYLINDRICAL_SURFACE('',#891,4.);
#893=ORIENTED_EDGE('',*,*,#624,.T.);
#894=CARTESIAN_POINT('',(0.,2.46642274315238,9.06746828136984));
#895=DIRECTION('',(-1.,0.,0.));
#896=DIRECTION('',(0.,0.951056516295152,0.309016994374952));
#897=AXIS2_PLACEMENT_3D('',#894,#895,#896);
#898=CIRCLE('',#897,4.);
#899=CARTESIAN_POINT('',(0.,-1.1725414088933,7.40676364172845));
#900=VERTEX_POINT('',#899);
#901=EDGE_CURVE('E535',#900,#623,#898,.T.);
#902=ORIENTED_EDGE('',*,*,#901,.F.);
#903=DIRECTION('',(-1.,0.,0.));
#904=VECTOR('',#903,1.);
#905=CARTESIAN_POINT('',(16.,-1.1725414088933,7.40676364172845));
#906=LINE('',#905,#904);
#907=EDGE_CURVE('E547',#142,#900,#906,.T.);
#908=ORIENTED_EDGE('',*,*,#907,.F.);
#909=ORIENTED_EDGE('',*,*,#145,.T.);
#910=EDGE_LOOP('',(#893,#902,#908,#909));
#911=FACE_BOUND('',#910,.T.);
#912=ADVANCED_FACE('F833',(#911),#892,.T.);
#913=CARTESIAN_POINT('',(16.,-7.32510204594217,5.88600902124022));
#914=DIRECTION('',(-1.,0.,0.));
#915=DIRECTION('',(0.,0.,1.));
#916=AXIS2_PLACEMENT_3D('',#913,#914,#915);
#917=CYLINDRICAL_SURFACE('',#916,4.);
#918=ORIENTED_EDGE('',*,*,#611,.T.);
#919=ORIENTED_EDGE('',*,*,#163,.T.);
#920=DIRECTION('',(-1.,0.,0.));
#921=VECTOR('',#920,1.);
#922=CARTESIAN_POINT('',(16.,-3.4049805094211,6.68140020732648));
#923=LINE('',#922,#921);
#924=CARTESIAN_POINT('',(0.,-3.4049805094211,6.68140020732648));
#925=VERTEX_POINT('',#924);
#926=EDGE_CURVE('E550',#153,#925,#923,.T.);
#927=ORIENTED_EDGE('',*,*,#926,.T.);
#928=CARTESIAN_POINT('',(0.,-7.32510204594217,5.88600902124022));
#929=DIRECTION('',(1.,0.,0.));
#930=DIRECTION('',(0.,0.,-1.));
#931=AXIS2_PLACEMENT_3D('',#928,#929,#930);
#932=CIRCLE('',#931,4.);
#933=EDGE_CURVE('E639',#925,#610,#932,.T.);
#934=ORIENTED_EDGE('',*,*,#933,.T.);
#935=EDGE_LOOP('',(#918,#919,#927,#934));
#936=FACE_BOUND('',#935,.T.);
#937=ADVANCED_FACE('F829',(#936),#917,.T.);
#938=CARTESIAN_POINT('',(16.,0.,0.));
#939=DIRECTION('',(-1.,0.,0.));
#940=DIRECTION('',(0.,0.,1.));
#941=AXIS2_PLACEMENT_3D('',#938,#939,#940);
#942=CYLINDRICAL_SURFACE('',#941,7.499);
#943=CARTESIAN_POINT('',(0.,0.,0.));
#944=DIRECTION('',(-1.,0.,0.));
#945=DIRECTION('',(0.,0.951056516295152,0.309016994374952));
#946=AXIS2_PLACEMENT_3D('',#943,#944,#945);
#947=CIRCLE('',#946,7.499);
#948=EDGE_CURVE('E538',#925,#900,#947,.T.);
#949=ORIENTED_EDGE('',*,*,#948,.F.);
#950=ORIENTED_EDGE('',*,*,#926,.F.);
#951=ORIENTED_EDGE('',*,*,#154,.T.);
#952=ORIENTED_EDGE('',*,*,#907,.T.);
#953=EDGE_LOOP('',(#949,#950,#951,#952));
#954=FACE_BOUND('',#953,.T.);
#955=ADVANCED_FACE('F825',(#954),#942,.T.);
#956=CARTESIAN_POINT('',(16.,-3.33434621689583,8.78546284992771));
#957=DIRECTION('',(-1.,0.,0.));
#958=DIRECTION('',(0.,0.,1.));
#959=AXIS2_PLACEMENT_3D('',#956,#957,#958);
#960=CYLINDRICAL_SURFACE('',#959,4.);
#961=ORIENTED_EDGE('',*,*,#602,.T.);
#962=CARTESIAN_POINT('',(0.,-3.33434621689583,8.78546284992771));
#963=DIRECTION('',(-1.,0.,0.));
#964=DIRECTION('',(0.,0.587785252292469,0.809016994374951));
#965=AXIS2_PLACEMENT_3D('',#962,#963,#964);
#966=CIRCLE('',#965,4.);
#967=CARTESIAN_POINT('',(0.,-5.30219236222711,5.30299511162706));
#968=VERTEX_POINT('',#967);
#969=EDGE_CURVE('E513',#968,#601,#966,.T.);
#970=ORIENTED_EDGE('',*,*,#969,.F.);
#971=DIRECTION('',(-1.,0.,0.));
#972=VECTOR('',#971,1.);
#973=CARTESIAN_POINT('',(16.,-5.30219236222711,5.30299511162706));
#974=LINE('',#973,#972);
#975=EDGE_CURVE('E525',#180,#968,#974,.T.);
#976=ORIENTED_EDGE('',*,*,#975,.F.);
#977=ORIENTED_EDGE('',*,*,#181,.T.);
#978=EDGE_LOOP('',(#961,#970,#976,#977));
#979=FACE_BOUND('',#978,.T.);
#980=ADVANCED_FACE('F821',(#979),#960,.T.);
#981=CARTESIAN_POINT('',(16.,-9.38584133824337,0.456294373085347));
#982=DIRECTION('',(-1.,0.,0.));
#983=DIRECTION('',(0.,0.,1.));
#984=AXIS2_PLACEMENT_3D('',#981,#982,#983);
#985=CYLINDRICAL_SURFACE('',#984,4.);
#986=ORIENTED_EDGE('',*,*,#589,.T.);
#987=ORIENTED_EDGE('',*,*,#199,.T.);
#988=DIRECTION('',(-1.,0.,0.));
#989=VECTOR('',#988,1.);
#990=CARTESIAN_POINT('',(16.,-6.68191560416752,3.40396898616638));
#991=LINE('',#990,#989);
#992=CARTESIAN_POINT('',(0.,-6.68191560416752,3.40396898616638));
#993=VERTEX_POINT('',#992);
#994=EDGE_CURVE('E528',#189,#993,#991,.T.);
#995=ORIENTED_EDGE('',*,*,#994,.T.);
#996=CARTESIAN_POINT('',(0.,-9.38584133824337,0.456294373085347));
#997=DIRECTION('',(1.,0.,0.));
#998=DIRECTION('',(0.,0.,-1.));
#999=AXIS2_PLACEMENT_3D('',#996,#997,#998);
#1000=CIRCLE('',#999,4.);
#1001=EDGE_CURVE('E641',#993,#588,#1000,.T.);
#1002=ORIENTED_EDGE('',*,*,#1001,.T.);
#1003=EDGE_LOOP('',(#986,#987,#995,#1002));
#1004=FACE_BOUND('',#1003,.T.);
#1005=ADVANCED_FACE('F817',(#1004),#985,.T.);
#1006=CARTESIAN_POINT('',(16.,0.,0.));
#1007=DIRECTION('',(-1.,0.,0.));
#1008=DIRECTION('',(0.,0.,1.));
#1009=AXIS2_PLACEMENT_3D('',#1006,#1007,#1008);
#1010=CYLINDRICAL_SURFACE('',#1009,7.499);
#1011=CARTESIAN_POINT('',(0.,0.,0.));
#1012=DIRECTION('',(-1.,0.,0.));
#1013=DIRECTION('',(0.,0.587785252292469,0.809016994374951));
#1014=AXIS2_PLACEMENT_3D('',#1011,#1012,#1013);
#1015=CIRCLE('',#1014,7.499);
#1016=EDGE_CURVE('E516',#993,#968,#1015,.T.);
#1017=ORIENTED_EDGE('',*,*,#1016,.F.);
#1018=ORIENTED_EDGE('',*,*,#994,.F.);
#1019=ORIENTED_EDGE('',*,*,#190,.T.);
#1020=ORIENTED_EDGE('',*,*,#975,.T.);
#1021=EDGE_LOOP('',(#1017,#1018,#1019,#1020));
#1022=FACE_BOUND('',#1021,.T.);
#1023=ADVANCED_FACE('F813',(#1022),#1010,.T.);
#1024=CARTESIAN_POINT('',(16.,-7.86150825234946,5.14770921671269));
#1025=DIRECTION('',(-1.,0.,0.));
#1026=DIRECTION('',(0.,0.,1.));
#1027=AXIS2_PLACEMENT_3D('',#1024,#1025,#1026);
#1028=CYLINDRICAL_SURFACE('',#1027,4.);
#1029=ORIENTED_EDGE('',*,*,#580,.T.);
#1030=CARTESIAN_POINT('',(0.,-7.86150825234946,5.14770921671269));
#1031=DIRECTION('',(-1.,0.,0.));
#1032=DIRECTION('',(0.,0.,1.));
#1033=AXIS2_PLACEMENT_3D('',#1030,#1031,#1032);
#1034=CIRCLE('',#1033,4.);
#1035=CARTESIAN_POINT('',(0.,-7.40658604808024,1.17366269105867));
#1036=VERTEX_POINT('',#1035);
#1037=EDGE_CURVE('E491',#1036,#579,#1034,.T.);
#1038=ORIENTED_EDGE('',*,*,#1037,.F.);
#1039=DIRECTION('',(-1.,0.,0.));
#1040=VECTOR('',#1039,1.);
#1041=CARTESIAN_POINT('',(16.,-7.40658604808024,1.17366269105867));
#1042=LINE('',#1041,#1040);
#1043=EDGE_CURVE('E503',#211,#1036,#1042,.T.);
#1044=ORIENTED_EDGE('',*,*,#1043,.F.);
#1045=ORIENTED_EDGE('',*,*,#212,.T.);
#1046=EDGE_LOOP('',(#1029,#1038,#1044,#1045));
#1047=FACE_BOUND('',#1046,.T.);
#1048=ADVANCED_FACE('F809',(#1047),#1028,.T.);
#1049=CARTESIAN_POINT('',(16.,-7.86150825234939,-5.1477092167128));
#1050=DIRECTION('',(-1.,0.,0.));
#1051=DIRECTION('',(0.,0.,1.));
#1052=AXIS2_PLACEMENT_3D('',#1049,#1050,#1051);
#1053=CYLINDRICAL_SURFACE('',#1052,4.);
#1054=ORIENTED_EDGE('',*,*,#567,.T.);
#1055=ORIENTED_EDGE('',*,*,#230,.T.);
#1056=DIRECTION('',(-1.,0.,0.));
#1057=VECTOR('',#1056,1.);
#1058=CARTESIAN_POINT('',(16.,-7.40658604808023,-1.17366269105877));
#1059=LINE('',#1058,#1057);
#1060=CARTESIAN_POINT('',(0.,-7.40658604808023,-1.17366269105877));
#1061=VERTEX_POINT('',#1060);
#1062=EDGE_CURVE('E506',#220,#1061,#1059,.T.);
#1063=ORIENTED_EDGE('',*,*,#1062,.T.);
#1064=CARTESIAN_POINT('',(0.,-7.86150825234939,-5.1477092167128));
#1065=DIRECTION('',(1.,0.,0.));
#1066=DIRECTION('',(0.,0.,-1.));
#1067=AXIS2_PLACEMENT_3D('',#1064,#1065,#1066);
#1068=CIRCLE('',#1067,4.);
#1069=EDGE_CURVE('E643',#1061,#566,#1068,.T.);
#1070=ORIENTED_EDGE('',*,*,#1069,.T.);
#1071=EDGE_LOOP('',(#1054,#1055,#1063,#1070));
#1072=FACE_BOUND('',#1071,.T.);
#1073=ADVANCED_FACE('F805',(#1072),#1053,.T.);
#1074=CARTESIAN_POINT('',(16.,0.,0.));
#1075=DIRECTION('',(-1.,0.,0.));
#1076=DIRECTION('',(0.,0.,1.));
#1077=AXIS2_PLACEMENT_3D('',#1074,#1075,#1076);
#1078=CYLINDRICAL_SURFACE('',#1077,7.499);
#1079=CARTESIAN_POINT('',(0.,0.,0.));
#1080=DIRECTION('',(-1.,0.,0.));
#1081=DIRECTION('',(0.,0.,1.));
#1082=AXIS2_PLACEMENT_3D('',#1079,#1080,#1081);
#1083=CIRCLE('',#1082,7.499);
#1084=EDGE_CURVE('E494',#1061,#1036,#1083,.T.);
#1085=ORIENTED_EDGE('',*,*,#1084,.F.);
#1086=ORIENTED_EDGE('',*,*,#1062,.F.);
#1087=ORIENTED_EDGE('',*,*,#221,.T.);
#1088=ORIENTED_EDGE('',*,*,#1043,.T.);
#1089=EDGE_LOOP('',(#1085,#1086,#1087,#1088));
#1090=FACE_BOUND('',#1089,.T.);
#1091=ADVANCED_FACE('F801',(#1090),#1078,.T.);
#1092=CARTESIAN_POINT('',(16.,-9.38584133824337,-0.456294373085482));
#1093=DIRECTION('',(-1.,0.,0.));
#1094=DIRECTION('',(0.,0.,1.));
#1095=AXIS2_PLACEMENT_3D('',#1092,#1093,#1094);
#1096=CYLINDRICAL_SURFACE('',#1095,4.);
#1097=ORIENTED_EDGE('',*,*,#558,.T.);
#1098=CARTESIAN_POINT('',(0.,-9.38584133824337,-0.456294373085482));
#1099=DIRECTION('',(-1.,0.,0.));
#1100=DIRECTION('',(0.,-0.58778525229248,0.809016994374942));
#1101=AXIS2_PLACEMENT_3D('',#1098,#1099,#1100);
#1102=CIRCLE('',#1101,4.);
#1103=CARTESIAN_POINT('',(0.,-6.68191560416748,-3.40396898616647));
#1104=VERTEX_POINT('',#1103);
#1105=EDGE_CURVE('E469',#1104,#557,#1102,.T.);
#1106=ORIENTED_EDGE('',*,*,#1105,.F.);
#1107=DIRECTION('',(-1.,0.,0.));
#1108=VECTOR('',#1107,1.);
#1109=CARTESIAN_POINT('',(16.,-6.68191560416748,-3.40396898616647));
#1110=LINE('',#1109,#1108);
#1111=EDGE_CURVE('E481',#242,#1104,#1110,.T.);
#1112=ORIENTED_EDGE('',*,*,#1111,.F.);
#1113=ORIENTED_EDGE('',*,*,#243,.T.);
#1114=EDGE_LOOP('',(#1097,#1106,#1112,#1113));
#1115=FACE_BOUND('',#1114,.T.);
#1116=ADVANCED_FACE('F797',(#1115),#1096,.T.);
#1117=CARTESIAN_POINT('',(16.,-3.33434621689571,-8.78546284992776));
#1118=DIRECTION('',(-1.,0.,0.));
#1119=DIRECTION('',(0.,0.,1.));
#1120=AXIS2_PLACEMENT_3D('',#1117,#1118,#1119);
#1121=CYLINDRICAL_SURFACE('',#1120,4.);
#1122=ORIENTED_EDGE('',*,*,#545,.T.);
#1123=ORIENTED_EDGE('',*,*,#261,.T.);
#1124=DIRECTION('',(-1.,0.,0.));
#1125=VECTOR('',#1124,1.);
#1126=CARTESIAN_POINT('',(16.,-5.30219236222703,-5.30299511162714));
#1127=LINE('',#1126,#1125);
#1128=CARTESIAN_POINT('',(0.,-5.30219236222703,-5.30299511162714));
#1129=VERTEX_POINT('',#1128);
#1130=EDGE_CURVE('E484',#251,#1129,#1127,.T.);
#1131=ORIENTED_EDGE('',*,*,#1130,.T.);
#1132=CARTESIAN_POINT('',(0.,-3.33434621689571,-8.78546284992776));
#1133=DIRECTION('',(1.,0.,0.));
#1134=DIRECTION('',(0.,0.,-1.));
#1135=AXIS2_PLACEMENT_3D('',#1132,#1133,#1134);
#1136=CIRCLE('',#1135,4.);
#1137=EDGE_CURVE('E645',#1129,#544,#1136,.T.);
#1138=ORIENTED_EDGE('',*,*,#1137,.T.);
#1139=EDGE_LOOP('',(#1122,#1123,#1131,#1138));
#1140=FACE_BOUND('',#1139,.T.);
#1141=ADVANCED_FACE('F793',(#1140),#1121,.T.);
#1142=CARTESIAN_POINT('',(16.,0.,0.));
#1143=DIRECTION('',(-1.,0.,0.));
#1144=DIRECTION('',(0.,0.,1.));
#1145=AXIS2_PLACEMENT_3D('',#1142,#1143,#1144);
#1146=CYLINDRICAL_SURFACE('',#1145,7.499);
#1147=CARTESIAN_POINT('',(0.,0.,0.));
#1148=DIRECTION('',(-1.,0.,0.));
#1149=DIRECTION('',(0.,-0.58778525229248,0.809016994374942));
#1150=AXIS2_PLACEMENT_3D('',#1147,#1148,#1149);
#1151=CIRCLE('',#1150,7.499);
#1152=EDGE_CURVE('E472',#1129,#1104,#1151,.T.);
#1153=ORIENTED_EDGE('',*,*,#1152,.F.);
#1154=ORIENTED_EDGE('',*,*,#1130,.F.);
#1155=ORIENTED_EDGE('',*,*,#252,.T.);
#1156=ORIENTED_EDGE('',*,*,#1111,.T.);
#1157=EDGE_LOOP('',(#1153,#1154,#1155,#1156));
#1158=FACE_BOUND('',#1157,.T.);
#1159=ADVANCED_FACE('F789',(#1158),#1146,.T.);
#1160=CARTESIAN_POINT('',(16.,-7.32510204594209,-5.88600902124032));
#1161=DIRECTION('',(-1.,0.,0.));
#1162=DIRECTION('',(0.,0.,1.));
#1163=AXIS2_PLACEMENT_3D('',#1160,#1161,#1162);
#1164=CYLINDRICAL_SURFACE('',#1163,4.);
#1165=ORIENTED_EDGE('',*,*,#536,.T.);
#1166=CARTESIAN_POINT('',(0.,-7.32510204594209,-5.88600902124032));
#1167=DIRECTION('',(-1.,0.,0.));
#1168=DIRECTION('',(0.,-0.951056516295156,0.309016994374938));
#1169=AXIS2_PLACEMENT_3D('',#1166,#1167,#1168);
#1170=CIRCLE('',#1169,4.);
#1171=CARTESIAN_POINT('',(0.,-3.40498050942101,-6.68140020732653));
#1172=VERTEX_POINT('',#1171);
#1173=EDGE_CURVE('E447',#1172,#535,#1170,.T.);
#1174=ORIENTED_EDGE('',*,*,#1173,.F.);
#1175=DIRECTION('',(-1.,0.,0.));
#1176=VECTOR('',#1175,1.);
#1177=CARTESIAN_POINT('',(16.,-3.40498050942101,-6.68140020732653));
#1178=LINE('',#1177,#1176);
#1179=EDGE_CURVE('E459',#273,#1172,#1178,.T.);
#1180=ORIENTED_EDGE('',*,*,#1179,.F.);
#1181=ORIENTED_EDGE('',*,*,#274,.T.);
#1182=EDGE_LOOP('',(#1165,#1174,#1180,#1181));
#1183=FACE_BOUND('',#1182,.T.);
#1184=ADVANCED_FACE('F785',(#1183),#1164,.T.);
#1185=CARTESIAN_POINT('',(16.,2.4664227431525,-9.06746828136981));
#1186=DIRECTION('',(-1.,0.,0.));
#1187=DIRECTION('',(0.,0.,1.));
#1188=AXIS2_PLACEMENT_3D('',#1185,#1186,#1187);
#1189=CYLINDRICAL_SURFACE('',#1188,4.);
#1190=ORIENTED_EDGE('',*,*,#523,.T.);
#1191=ORIENTED_EDGE('',*,*,#292,.T.);
#1192=DIRECTION('',(-1.,0.,0.));
#1193=VECTOR('',#1192,1.);
#1194=CARTESIAN_POINT('',(16.,-1.1725414088932,-7.40676364172847));
#1195=LINE('',#1194,#1193);
#1196=CARTESIAN_POINT('',(0.,-1.1725414088932,-7.40676364172847));
#1197=VERTEX_POINT('',#1196);
#1198=EDGE_CURVE('E462',#282,#1197,#1195,.T.);
#1199=ORIENTED_EDGE('',*,*,#1198,.T.);
#1200=CARTESIAN_POINT('',(0.,2.4664227431525,-9.06746828136981));
#1201=DIRECTION('',(1.,0.,0.));
#1202=DIRECTION('',(0.,0.,-1.));
#1203=AXIS2_PLACEMENT_3D('',#1200,#1201,#1202);
#1204=CIRCLE('',#1203,4.);
#1205=EDGE_CURVE('E647',#1197,#522,#1204,.T.);
#1206=ORIENTED_EDGE('',*,*,#1205,.T.);
#1207=EDGE_LOOP('',(#1190,#1191,#1199,#1206));
#1208=FACE_BOUND('',#1207,.T.);
#1209=ADVANCED_FACE('F781',(#1208),#1189,.T.);
#1210=CARTESIAN_POINT('',(16.,0.,0.));
#1211=DIRECTION('',(-1.,0.,0.));
#1212=DIRECTION('',(0.,0.,1.));
#1213=AXIS2_PLACEMENT_3D('',#1210,#1211,#1212);
#1214=CYLINDRICAL_SURFACE('',#1213,7.499);
#1215=CARTESIAN_POINT('',(0.,0.,0.));
#1216=DIRECTION('',(-1.,0.,0.));
#1217=DIRECTION('',(0.,-0.951056516295156,0.309016994374938));
#1218=AXIS2_PLACEMENT_3D('',#1215,#1216,#1217);
#1219=CIRCLE('',#1218,7.499);
#1220=EDGE_CURVE('E450',#1197,#1172,#1219,.T.);
#1221=ORIENTED_EDGE('',*,*,#1220,.F.);
#1222=ORIENTED_EDGE('',*,*,#1198,.F.);
#1223=ORIENTED_EDGE('',*,*,#283,.T.);
#1224=ORIENTED_EDGE('',*,*,#1179,.T.);
#1225=EDGE_LOOP('',(#1221,#1222,#1223,#1224));
#1226=FACE_BOUND('',#1225,.T.);
#1227=ADVANCED_FACE('F778',(#1226),#1214,.T.);
#1228=CARTESIAN_POINT('',(16.,-2.46642274315231,-9.06746828136986));
#1229=DIRECTION('',(-1.,0.,0.));
#1230=DIRECTION('',(0.,0.,1.));
#1231=AXIS2_PLACEMENT_3D('',#1228,#1229,#1230);
#1232=CYLINDRICAL_SURFACE('',#1231,4.);
#1233=ORIENTED_EDGE('',*,*,#514,.T.);
#1234=CARTESIAN_POINT('',(0.,-2.46642274315231,-9.06746828136986));
#1235=DIRECTION('',(-1.,0.,0.));
#1236=DIRECTION('',(0.,-0.95105651629515,-0.309016994374958));
#1237=AXIS2_PLACEMENT_3D('',#1234,#1235,#1236);
#1238=CIRCLE('',#1237,4.);
#1239=CARTESIAN_POINT('',(0.,1.17254140889336,-7.40676364172844));
#1240=VERTEX_POINT('',#1239);
#1241=EDGE_CURVE('E52',#1240,#513,#1238,.T.);
#1242=ORIENTED_EDGE('',*,*,#1241,.F.);
#1243=DIRECTION('',(-1.,0.,0.));
#1244=VECTOR('',#1243,1.);
#1245=CARTESIAN_POINT('',(16.,1.17254140889336,-7.40676364172844));
#1246=LINE('',#1245,#1244);
#1247=EDGE_CURVE('E438',#304,#1240,#1246,.T.);
#1248=ORIENTED_EDGE('',*,*,#1247,.F.);
#1249=ORIENTED_EDGE('',*,*,#305,.T.);
#1250=EDGE_LOOP('',(#1233,#1242,#1248,#1249));
#1251=FACE_BOUND('',#1250,.T.);
#1252=ADVANCED_FACE('F774',(#1251),#1232,.T.);
#1253=CARTESIAN_POINT('',(16.,7.32510204594221,-5.88600902124017));
#1254=DIRECTION('',(-1.,0.,0.));
#1255=DIRECTION('',(0.,0.,1.));
#1256=AXIS2_PLACEMENT_3D('',#1253,#1254,#1255);
#1257=CYLINDRICAL_SURFACE('',#1256,4.);
#1258=ORIENTED_EDGE('',*,*,#474,.T.);
#1259=ORIENTED_EDGE('',*,*,#323,.T.);
#1260=DIRECTION('',(-1.,0.,0.));
#1261=VECTOR('',#1260,1.);
#1262=CARTESIAN_POINT('',(16.,3.40498050942115,-6.68140020732646));
#1263=LINE('',#1262,#1261);
#1264=CARTESIAN_POINT('',(0.,3.40498050942115,-6.68140020732646));
#1265=VERTEX_POINT('',#1264);
#1266=EDGE_CURVE('E440',#313,#1265,#1263,.T.);
#1267=ORIENTED_EDGE('',*,*,#1266,.T.);
#1268=CARTESIAN_POINT('',(0.,7.32510204594221,-5.88600902124017));
#1269=DIRECTION('',(1.,0.,0.));
#1270=DIRECTION('',(0.,0.,-1.));
#1271=AXIS2_PLACEMENT_3D('',#1268,#1269,#1270);
#1272=CIRCLE('',#1271,4.);
#1273=EDGE_CURVE('E649',#1265,#473,#1272,.T.);
#1274=ORIENTED_EDGE('',*,*,#1273,.T.);
#1275=EDGE_LOOP('',(#1258,#1259,#1267,#1274));
#1276=FACE_BOUND('',#1275,.T.);
#1277=ADVANCED_FACE('F770',(#1276),#1257,.T.);
#1278=CARTESIAN_POINT('',(16.,0.,0.));
#1279=DIRECTION('',(-1.,0.,0.));
#1280=DIRECTION('',(0.,0.,1.));
#1281=AXIS2_PLACEMENT_3D('',#1278,#1279,#1280);
#1282=CYLINDRICAL_SURFACE('',#1281,7.499);
#1283=CARTESIAN_POINT('',(0.,0.,0.));
#1284=DIRECTION('',(-1.,0.,0.));
#1285=DIRECTION('',(0.,-0.95105651629515,-0.309016994374958));
#1286=AXIS2_PLACEMENT_3D('',#1283,#1284,#1285);
#1287=CIRCLE('',#1286,7.499);
#1288=EDGE_CURVE('E429',#1265,#1240,#1287,.T.);
#1289=ORIENTED_EDGE('',*,*,#1288,.F.);
#1290=ORIENTED_EDGE('',*,*,#1266,.F.);
#1291=ORIENTED_EDGE('',*,*,#314,.T.);
#1292=ORIENTED_EDGE('',*,*,#1247,.T.);
#1293=EDGE_LOOP('',(#1289,#1290,#1291,#1292));
#1294=FACE_BOUND('',#1293,.T.);
#1295=ADVANCED_FACE('F766',(#1294),#1282,.T.);
#1296=CARTESIAN_POINT('',(16.,3.3343462168959,-8.78546284992768));
#1297=DIRECTION('',(-1.,0.,0.));
#1298=DIRECTION('',(0.,0.,1.));
#1299=AXIS2_PLACEMENT_3D('',#1296,#1297,#1298);
#1300=CYLINDRICAL_SURFACE('',#1299,4.);
#1301=ORIENTED_EDGE('',*,*,#465,.T.);
#1302=CARTESIAN_POINT('',(0.,3.3343462168959,-8.78546284992768));
#1303=DIRECTION('',(-1.,0.,0.));
#1304=DIRECTION('',(0.,-0.587785252292462,-0.809016994374955));
#1305=AXIS2_PLACEMENT_3D('',#1302,#1303,#1304);
#1306=CIRCLE('',#1305,4.);
#1307=CARTESIAN_POINT('',(0.,5.30219236222715,-5.30299511162702));
#1308=VERTEX_POINT('',#1307);
#1309=EDGE_CURVE('E408',#1308,#464,#1306,.T.);
#1310=ORIENTED_EDGE('',*,*,#1309,.F.);
#1311=DIRECTION('',(-1.,0.,0.));
#1312=VECTOR('',#1311,1.);
#1313=CARTESIAN_POINT('',(16.,5.30219236222715,-5.30299511162702));
#1314=LINE('',#1313,#1312);
#1315=EDGE_CURVE('E420',#335,#1308,#1314,.T.);
#1316=ORIENTED_EDGE('',*,*,#1315,.F.);
#1317=ORIENTED_EDGE('',*,*,#336,.T.);
#1318=EDGE_LOOP('',(#1301,#1310,#1316,#1317));
#1319=FACE_BOUND('',#1318,.T.);
#1320=ADVANCED_FACE('F762',(#1319),#1300,.T.);
#1321=CARTESIAN_POINT('',(16.,9.38584133824337,-0.456294373085277));
#1322=DIRECTION('',(-1.,0.,0.));
#1323=DIRECTION('',(0.,0.,1.));
#1324=AXIS2_PLACEMENT_3D('',#1321,#1322,#1323);
#1325=CYLINDRICAL_SURFACE('',#1324,4.);
#1326=ORIENTED_EDGE('',*,*,#492,.T.);
#1327=ORIENTED_EDGE('',*,*,#354,.T.);
#1328=DIRECTION('',(-1.,0.,0.));
#1329=VECTOR('',#1328,1.);
#1330=CARTESIAN_POINT('',(16.,6.68191560416755,-3.40396898616632));
#1331=LINE('',#1330,#1329);
#1332=CARTESIAN_POINT('',(0.,6.68191560416755,-3.40396898616632));
#1333=VERTEX_POINT('',#1332);
#1334=EDGE_CURVE('E422',#344,#1333,#1331,.T.);
#1335=ORIENTED_EDGE('',*,*,#1334,.T.);
#1336=CARTESIAN_POINT('',(0.,9.38584133824337,-0.456294373085277));
#1337=DIRECTION('',(1.,0.,0.));
#1338=DIRECTION('',(0.,0.,-1.));
#1339=AXIS2_PLACEMENT_3D('',#1336,#1337,#1338);
#1340=CIRCLE('',#1339,4.);
#1341=EDGE_CURVE('E651',#1333,#491,#1340,.T.);
#1342=ORIENTED_EDGE('',*,*,#1341,.T.);
#1343=EDGE_LOOP('',(#1326,#1327,#1335,#1342));
#1344=FACE_BOUND('',#1343,.T.);
#1345=ADVANCED_FACE('F758',(#1344),#1325,.T.);
#1346=CARTESIAN_POINT('',(16.,0.,0.));
#1347=DIRECTION('',(-1.,0.,0.));
#1348=DIRECTION('',(0.,0.,1.));
#1349=AXIS2_PLACEMENT_3D('',#1346,#1347,#1348);
#1350=CYLINDRICAL_SURFACE('',#1349,7.499);
#1351=CARTESIAN_POINT('',(0.,0.,0.));
#1352=DIRECTION('',(-1.,0.,0.));
#1353=DIRECTION('',(0.,-0.587785252292462,-0.809016994374955));
#1354=AXIS2_PLACEMENT_3D('',#1351,#1352,#1353);
#1355=CIRCLE('',#1354,7.499);
#1356=EDGE_CURVE('E411',#1333,#1308,#1355,.T.);
#1357=ORIENTED_EDGE('',*,*,#1356,.F.);
#1358=ORIENTED_EDGE('',*,*,#1334,.F.);
#1359=ORIENTED_EDGE('',*,*,#345,.T.);
#1360=ORIENTED_EDGE('',*,*,#1315,.T.);
#1361=EDGE_LOOP('',(#1357,#1358,#1359,#1360));
#1362=FACE_BOUND('',#1361,.T.);
#1363=ADVANCED_FACE('F754',(#1362),#1350,.T.);
#1364=CARTESIAN_POINT('',(-2.,0.,0.));
#1365=DIRECTION('',(1.,0.,0.));
#1366=DIRECTION('',(0.,0.,-1.));
#1367=AXIS2_PLACEMENT_3D('',#1364,#1365,#1366);
#1368=CYLINDRICAL_SURFACE('',#1367,12.5);
#1369=ORIENTED_EDGE('',*,*,#115,.F.);
#1370=EDGE_LOOP('',(#1369));
#1371=FACE_BOUND('',#1370,.T.);
#1372=CARTESIAN_POINT('',(0.,0.,0.));
#1373=DIRECTION('',(-1.,0.,0.));
#1374=DIRECTION('',(0.,0.,1.));
#1375=AXIS2_PLACEMENT_3D('',#1372,#1373,#1374);
#1376=CIRCLE('',#1375,12.5);
#1377=CARTESIAN_POINT('',(0.,0.,12.5));
#1378=VERTEX_POINT('',#1377);
#1379=EDGE_CURVE('E402',#1378,#1378,#1376,.T.);
#1380=ORIENTED_EDGE('',*,*,#1379,.T.);
#1381=EDGE_LOOP('',(#1380));
#1382=FACE_BOUND('',#1381,.T.);
#1383=ADVANCED_FACE('F747',(#1371,#1382),#1368,.T.);
#1384=CARTESIAN_POINT('',(0.,0.,0.));
#1385=DIRECTION('',(-1.,0.,0.));
#1386=DIRECTION('',(0.,0.,1.));
#1387=AXIS2_PLACEMENT_3D('',#1384,#1385,#1386);
#1388=PLANE('',#1387);
#1389=ORIENTED_EDGE('',*,*,#1016,.T.);
#1390=ORIENTED_EDGE('',*,*,#969,.T.);
#1391=ORIENTED_EDGE('',*,*,#613,.T.);
#1392=ORIENTED_EDGE('',*,*,#933,.F.);
#1393=ORIENTED_EDGE('',*,*,#948,.T.);
#1394=ORIENTED_EDGE('',*,*,#901,.T.);
#1395=ORIENTED_EDGE('',*,*,#635,.T.);
#1396=ORIENTED_EDGE('',*,*,#865,.F.);
#1397=ORIENTED_EDGE('',*,*,#880,.T.);
#1398=ORIENTED_EDGE('',*,*,#833,.T.);
#1399=ORIENTED_EDGE('',*,*,#657,.T.);
#1400=ORIENTED_EDGE('',*,*,#797,.F.);
#1401=ORIENTED_EDGE('',*,*,#812,.T.);
#1402=ORIENTED_EDGE('',*,*,#765,.T.);
#1403=ORIENTED_EDGE('',*,*,#679,.T.);
#1404=ORIENTED_EDGE('',*,*,#729,.F.);
#1405=ORIENTED_EDGE('',*,*,#744,.T.);
#1406=ORIENTED_EDGE('',*,*,#697,.T.);
#1407=ORIENTED_EDGE('',*,*,#496,.T.);
#1408=ORIENTED_EDGE('',*,*,#1341,.F.);
#1409=ORIENTED_EDGE('',*,*,#1356,.T.);
#1410=ORIENTED_EDGE('',*,*,#1309,.T.);
#1411=ORIENTED_EDGE('',*,*,#481,.T.);
#1412=ORIENTED_EDGE('',*,*,#1273,.F.);
#1413=ORIENTED_EDGE('',*,*,#1288,.T.);
#1414=ORIENTED_EDGE('',*,*,#1241,.T.);
#1415=ORIENTED_EDGE('',*,*,#525,.T.);
#1416=ORIENTED_EDGE('',*,*,#1205,.F.);
#1417=ORIENTED_EDGE('',*,*,#1220,.T.);
#1418=ORIENTED_EDGE('',*,*,#1173,.T.);
#1419=ORIENTED_EDGE('',*,*,#547,.T.);
#1420=ORIENTED_EDGE('',*,*,#1137,.F.);
#1421=ORIENTED_EDGE('',*,*,#1152,.T.);
#1422=ORIENTED_EDGE('',*,*,#1105,.T.);
#1423=ORIENTED_EDGE('',*,*,#569,.T.);
#1424=ORIENTED_EDGE('',*,*,#1069,.F.);
#1425=ORIENTED_EDGE('',*,*,#1084,.T.);
#1426=ORIENTED_EDGE('',*,*,#1037,.T.);
#1427=ORIENTED_EDGE('',*,*,#591,.T.);
#1428=ORIENTED_EDGE('',*,*,#1001,.F.);
#1429=EDGE_LOOP('',(#1389,#1390,#1391,#1392,#1393,#1394,#1395,#1396,#1397,#1398,#1399,#1400,
#1401,#1402,#1403,#1404,#1405,#1406,#1407,#1408,#1409,#1410,#1411,#1412,#1413,#1414,#1415,#1416,
#1417,#1418,#1419,#1420,#1421,#1422,#1423,#1424,#1425,#1426,#1427,#1428));
#1430=FACE_BOUND('',#1429,.T.);
#1431=ORIENTED_EDGE('',*,*,#1379,.F.);
#1432=EDGE_LOOP('',(#1431));
#1433=FACE_BOUND('',#1432,.T.);
#1434=ADVANCED_FACE('F743',(#1430,#1433),#1388,.F.);
#1435=CARTESIAN_POINT('',(-3.3,0.,0.));
#1436=DIRECTION('',(1.,0.,0.));
#1437=DIRECTION('',(0.,0.,-1.));
#1438=AXIS2_PLACEMENT_3D('',#1435,#1436,#1437);
#1439=CYLINDRICAL_SURFACE('',#1438,11.95);
#1440=CARTESIAN_POINT('',(-3.3,0.,0.));
#1441=DIRECTION('',(-1.,0.,0.));
#1442=DIRECTION('',(0.,0.,1.));
#1443=AXIS2_PLACEMENT_3D('',#1440,#1441,#1442);
#1444=CIRCLE('',#1443,11.95);
#1445=CARTESIAN_POINT('',(-3.3,0.,11.95));
#1446=VERTEX_POINT('',#1445);
#1447=EDGE_CURVE('E399',#1446,#1446,#1444,.T.);
#1448=ORIENTED_EDGE('',*,*,#1447,.F.);
#1449=EDGE_LOOP('',(#1448));
#1450=FACE_BOUND('',#1449,.T.);
#1451=ORIENTED_EDGE('',*,*,#126,.T.);
#1452=EDGE_LOOP('',(#1451));
#1453=FACE_BOUND('',#1452,.T.);
#1454=ADVANCED_FACE('F736',(#1450,#1453),#1439,.T.);
#1455=CARTESIAN_POINT('',(-3.3,0.,0.));
#1456=DIRECTION('',(-1.,0.,0.));
#1457=DIRECTION('',(0.,0.,1.));
#1458=AXIS2_PLACEMENT_3D('',#1455,#1456,#1457);
#1459=PLANE('',#1458);
#1460=CARTESIAN_POINT('',(-3.3,0.,0.));
#1461=DIRECTION('',(-1.,0.,0.));
#1462=DIRECTION('',(0.,0.,1.));
#1463=AXIS2_PLACEMENT_3D('',#1460,#1461,#1462);
#1464=CIRCLE('',#1463,12.5);
#1465=CARTESIAN_POINT('',(-3.3,0.,12.5));
#1466=VERTEX_POINT('',#1465);
#1467=EDGE_CURVE('E390',#1466,#1466,#1464,.T.);
#1468=ORIENTED_EDGE('',*,*,#1467,.F.);
#1469=EDGE_LOOP('',(#1468));
#1470=FACE_BOUND('',#1469,.T.);
#1471=ORIENTED_EDGE('',*,*,#1447,.T.);
#1472=EDGE_LOOP('',(#1471));
#1473=FACE_BOUND('',#1472,.T.);
#1474=ADVANCED_FACE('F733',(#1470,#1473),#1459,.F.);
#1475=CARTESIAN_POINT('',(-11.2,0.,0.));
#1476=DIRECTION('',(1.,0.,0.));
#1477=DIRECTION('',(0.,0.,-1.));
#1478=AXIS2_PLACEMENT_3D('',#1475,#1476,#1477);
#1479=CYLINDRICAL_SURFACE('',#1478,12.5);
#1480=CARTESIAN_POINT('',(-11.2,0.,0.));
#1481=DIRECTION('',(-1.,0.,0.));
#1482=DIRECTION('',(0.,0.,1.));
#1483=AXIS2_PLACEMENT_3D('',#1480,#1481,#1482);
#1484=CIRCLE('',#1483,12.5);
#1485=CARTESIAN_POINT('',(-11.2,0.,12.5));
#1486=VERTEX_POINT('',#1485);
#1487=EDGE_CURVE('E393',#1486,#1486,#1484,.T.);
#1488=ORIENTED_EDGE('',*,*,#1487,.F.);
#1489=EDGE_LOOP('',(#1488));
#1490=FACE_BOUND('',#1489,.T.);
#1491=ORIENTED_EDGE('',*,*,#1467,.T.);
#1492=EDGE_LOOP('',(#1491));
#1493=FACE_BOUND('',#1492,.T.);
#1494=ADVANCED_FACE('F724',(#1490,#1493),#1479,.T.);
#1495=CARTESIAN_POINT('',(-11.2,0.,0.));
#1496=DIRECTION('',(-1.,0.,0.));
#1497=DIRECTION('',(0.,0.,1.));
#1498=AXIS2_PLACEMENT_3D('',#1495,#1496,#1497);
#1499=PLANE('',#1498);
#1500=CARTESIAN_POINT('',(-11.2,0.,0.));
#1501=DIRECTION('',(-1.,0.,0.));
#1502=DIRECTION('',(0.,0.,1.));
#1503=AXIS2_PLACEMENT_3D('',#1500,#1501,#1502);
#1504=CIRCLE('',#1503,15.);
#1505=CARTESIAN_POINT('',(-11.2,0.,15.));
#1506=VERTEX_POINT('',#1505);
#1507=EDGE_CURVE('E384',#1506,#1506,#1504,.T.);
#1508=ORIENTED_EDGE('',*,*,#1507,.F.);
#1509=EDGE_LOOP('',(#1508));
#1510=FACE_BOUND('',#1509,.T.);
#1511=ORIENTED_EDGE('',*,*,#1487,.T.);
#1512=EDGE_LOOP('',(#1511));
#1513=FACE_BOUND('',#1512,.T.);
#1514=ADVANCED_FACE('F721',(#1510,#1513),#1499,.F.);
#1515=CARTESIAN_POINT('',(-14.2,0.,0.));
#1516=DIRECTION('',(1.,0.,0.));
#1517=DIRECTION('',(0.,0.,-1.));
#1518=AXIS2_PLACEMENT_3D('',#1515,#1516,#1517);
#1519=CYLINDRICAL_SURFACE('',#1518,15.);
#1520=ORIENTED_EDGE('',*,*,#87,.F.);
#1521=EDGE_LOOP('',(#1520));
#1522=FACE_BOUND('',#1521,.T.);
#1523=ORIENTED_EDGE('',*,*,#1507,.T.);
#1524=EDGE_LOOP('',(#1523));
#1525=FACE_BOUND('',#1524,.T.);
#1526=ADVANCED_FACE('F720',(#1522,#1525),#1519,.T.);
#1527=CARTESIAN_POINT('',(-15.8,0.,0.));
#1528=DIRECTION('',(1.,0.,0.));
#1529=DIRECTION('',(0.,0.,-1.));
#1530=AXIS2_PLACEMENT_3D('',#1527,#1528,#1529);
#1531=CYLINDRICAL_SURFACE('',#1530,14.3);
#1532=CARTESIAN_POINT('',(-15.8,0.,0.));
#1533=DIRECTION('',(-1.,0.,0.));
#1534=DIRECTION('',(0.,0.,1.));
#1535=AXIS2_PLACEMENT_3D('',#1532,#1533,#1534);
#1536=CIRCLE('',#1535,14.3);
#1537=CARTESIAN_POINT('',(-15.8,2.67203331863673,14.0481400172441));
#1538=VERTEX_POINT('',#1537);
#1539=CARTESIAN_POINT('',(-15.8,-5.29148098703015,13.284962512702));
#1540=VERTEX_POINT('',#1539);
#1541=EDGE_CURVE('E381',#1538,#1540,#1536,.T.);
#1542=ORIENTED_EDGE('',*,*,#1541,.F.);
#1543=CARTESIAN_POINT('',(-15.8,0.,0.));
#1544=DIRECTION('',(-1.,0.,0.));
#1545=DIRECTION('',(0.,0.,1.));
#1546=AXIS2_PLACEMENT_3D('',#1543,#1544,#1545);
#1547=CIRCLE('',#1546,14.3);
#1548=EDGE_CURVE('E348',#1540,#1538,#1547,.T.);
#1549=ORIENTED_EDGE('',*,*,#1548,.F.);
#1550=EDGE_LOOP('',(#1542,#1549));
#1551=FACE_BOUND('',#1550,.T.);
#1552=ORIENTED_EDGE('',*,*,#98,.T.);
#1553=EDGE_LOOP('',(#1552));
#1554=FACE_BOUND('',#1553,.T.);
#1555=ADVANCED_FACE('F671',(#1551,#1554),#1531,.T.);
#1556=CARTESIAN_POINT('',(-15.8,0.,0.));
#1557=DIRECTION('',(-1.,0.,0.));
#1558=DIRECTION('',(0.,0.,1.));
#1559=AXIS2_PLACEMENT_3D('',#1556,#1557,#1558);
#1560=PLANE('',#1559);
#1561=CARTESIAN_POINT('',(-15.8,0.,0.));
#1562=DIRECTION('',(-1.,0.,0.));
#1563=DIRECTION('',(0.,0.,1.));
#1564=AXIS2_PLACEMENT_3D('',#1561,#1562,#1563);
#1565=CIRCLE('',#1564,15.);
#1566=CARTESIAN_POINT('',(-15.8,2.60261600354227,14.7724876015553));
#1567=VERTEX_POINT('',#1566);
#1568=CARTESIAN_POINT('',(-15.8,-5.36089830212461,14.0093100970133));
#1569=VERTEX_POINT('',#1568);
#1570=EDGE_CURVE('E372',#1567,#1569,#1565,.T.);
#1571=ORIENTED_EDGE('',*,*,#1570,.F.);
#1572=DIRECTION('',(0.,-0.0953971880677595,0.995439288208359));
#1573=VECTOR('',#1572,1.);
#1574=CARTESIAN_POINT('',(-15.8,2.93956566887308,11.2565251102846));
#1575=LINE('',#1574,#1573);
#1576=EDGE_CURVE('E669',#1538,#1567,#1575,.T.);
#1577=ORIENTED_EDGE('',*,*,#1576,.F.);
#1578=ORIENTED_EDGE('',*,*,#1541,.T.);
#1579=DIRECTION('',(0.,0.0953971880677592,-0.995439288208359));
#1580=VECTOR('',#1579,1.);
#1581=CARTESIAN_POINT('',(-15.8,-5.69478846036176,17.4933476057425));
#1582=LINE('',#1581,#1580);
#1583=EDGE_CURVE('E325',#1569,#1540,#1582,.T.);
#1584=ORIENTED_EDGE('',*,*,#1583,.F.);
#1585=EDGE_LOOP('',(#1571,#1577,#1578,#1584));
#1586=FACE_BOUND('',#1585,.T.);
#1587=ADVANCED_FACE('F666',(#1586),#1560,.F.);
#1588=CARTESIAN_POINT('',(-31.7,0.,0.));
#1589=DIRECTION('',(1.,0.,0.));
#1590=DIRECTION('',(0.,0.,-1.));
#1591=AXIS2_PLACEMENT_3D('',#1588,#1589,#1590);
#1592=CYLINDRICAL_SURFACE('',#1591,15.);
#1593=CARTESIAN_POINT('',(-31.7,0.,0.));
#1594=DIRECTION('',(-1.,0.,0.));
#1595=DIRECTION('',(0.,0.,1.));
#1596=AXIS2_PLACEMENT_3D('',#1593,#1594,#1595);
#1597=CIRCLE('',#1596,15.);
#1598=CARTESIAN_POINT('',(-31.7,0.,15.));
#1599=VERTEX_POINT('',#1598);
#1600=EDGE_CURVE('E375',#1599,#1599,#1597,.T.);
#1601=ORIENTED_EDGE('',*,*,#1600,.F.);
#1602=EDGE_LOOP('',(#1601));
#1603=FACE_BOUND('',#1602,.T.);
#1604=CARTESIAN_POINT('',(-30.8,0.,0.));
#1605=DIRECTION('',(-1.,0.,0.));
#1606=DIRECTION('',(0.,0.,1.));
#1607=AXIS2_PLACEMENT_3D('',#1604,#1605,#1606);
#1608=CIRCLE('',#1607,15.);
#1609=CARTESIAN_POINT('',(-30.8,-5.36089830212461,14.0093100970133));
#1610=VERTEX_POINT('',#1609);
#1611=CARTESIAN_POINT('',(-30.8,2.60261600354227,14.7724876015553));
#1612=VERTEX_POINT('',#1611);
#1613=EDGE_CURVE('E659',#1610,#1612,#1608,.T.);
#1614=ORIENTED_EDGE('',*,*,#1613,.T.);
#1615=DIRECTION('',(1.,0.,0.));
#1616=VECTOR('',#1615,1.);
#1617=CARTESIAN_POINT('',(-31.7,2.60261600354227,14.7724876015553));
#1618=LINE('',#1617,#1616);
#1619=EDGE_CURVE('E11',#1612,#1567,#1618,.T.);
#1620=ORIENTED_EDGE('',*,*,#1619,.T.);
#1621=ORIENTED_EDGE('',*,*,#1570,.T.);
#1622=DIRECTION('',(1.,0.,0.));
#1623=VECTOR('',#1622,1.);
#1624=CARTESIAN_POINT('',(-31.7,-5.3608983021246,14.0093100970133));
#1625=LINE('',#1624,#1623);
#1626=EDGE_CURVE('E37',#1569,#1610,#1625,.F.);
#1627=ORIENTED_EDGE('',*,*,#1626,.T.);
#1628=EDGE_LOOP('',(#1614,#1620,#1621,#1627));
#1629=FACE_BOUND('',#1628,.T.);
#1630=ADVANCED_FACE('F663',(#1603,#1629),#1592,.T.);
#1631=CARTESIAN_POINT('',(-31.7,0.,0.));
#1632=DIRECTION('',(-1.,0.,0.));
#1633=DIRECTION('',(0.,0.,1.));
#1634=AXIS2_PLACEMENT_3D('',#1631,#1632,#1633);
#1635=PLANE('',#1634);
#1636=CARTESIAN_POINT('',(-31.7,0.,0.));
#1637=DIRECTION('',(-1.,0.,0.));
#1638=DIRECTION('',(0.,0.,1.));
#1639=AXIS2_PLACEMENT_3D('',#1636,#1637,#1638);
#1640=CIRCLE('',#1639,17.);
#1641=CARTESIAN_POINT('',(-31.7,0.,17.));
#1642=VERTEX_POINT('',#1641);
#1643=EDGE_CURVE('E366',#1642,#1642,#1640,.T.);
#1644=ORIENTED_EDGE('',*,*,#1643,.F.);
#1645=EDGE_LOOP('',(#1644));
#1646=FACE_BOUND('',#1645,.T.);
#1647=ORIENTED_EDGE('',*,*,#1600,.T.);
#1648=EDGE_LOOP('',(#1647));
#1649=FACE_BOUND('',#1648,.T.);
#1650=ADVANCED_FACE('F706',(#1646,#1649),#1635,.F.);
#1651=CARTESIAN_POINT('',(-33.7,0.,0.));
#1652=DIRECTION('',(1.,0.,0.));
#1653=DIRECTION('',(0.,0.,-1.));
#1654=AXIS2_PLACEMENT_3D('',#1651,#1652,#1653);
#1655=CYLINDRICAL_SURFACE('',#1654,17.);
#1656=ORIENTED_EDGE('',*,*,#59,.F.);
#1657=EDGE_LOOP('',(#1656));
#1658=FACE_BOUND('',#1657,.T.);
#1659=ORIENTED_EDGE('',*,*,#1643,.T.);
#1660=EDGE_LOOP('',(#1659));
#1661=FACE_BOUND('',#1660,.T.);
#1662=ADVANCED_FACE('F704',(#1658,#1661),#1655,.T.);
#1663=CARTESIAN_POINT('',(-41.6,0.,0.));
#1664=DIRECTION('',(1.,0.,0.));
#1665=DIRECTION('',(0.,0.,-1.));
#1666=AXIS2_PLACEMENT_3D('',#1663,#1664,#1665);
#1667=CYLINDRICAL_SURFACE('',#1666,12.5);
#1668=ORIENTED_EDGE('',*,*,#31,.F.);
#1669=EDGE_LOOP('',(#1668));
#1670=FACE_BOUND('',#1669,.T.);
#1671=ORIENTED_EDGE('',*,*,#70,.T.);
#1672=EDGE_LOOP('',(#1671));
#1673=FACE_BOUND('',#1672,.T.);
#1674=ADVANCED_FACE('F702',(#1670,#1673),#1667,.T.);
#1675=CARTESIAN_POINT('',(-42.9,0.,0.));
#1676=DIRECTION('',(1.,0.,0.));
#1677=DIRECTION('',(0.,0.,-1.));
#1678=AXIS2_PLACEMENT_3D('',#1675,#1676,#1677);
#1679=CYLINDRICAL_SURFACE('',#1678,11.95);
#1680=CARTESIAN_POINT('',(-42.9,0.,0.));
#1681=DIRECTION('',(-1.,0.,0.));
#1682=DIRECTION('',(0.,0.,1.));
#1683=AXIS2_PLACEMENT_3D('',#1680,#1681,#1682);
#1684=CIRCLE('',#1683,11.95);
#1685=CARTESIAN_POINT('',(-42.9,0.,11.95));
#1686=VERTEX_POINT('',#1685);
#1687=EDGE_CURVE('E357',#1686,#1686,#1684,.T.);
#1688=ORIENTED_EDGE('',*,*,#1687,.F.);
#1689=EDGE_LOOP('',(#1688));
#1690=FACE_BOUND('',#1689,.T.);
#1691=ORIENTED_EDGE('',*,*,#42,.T.);
#1692=EDGE_LOOP('',(#1691));
#1693=FACE_BOUND('',#1692,.T.);
#1694=ADVANCED_FACE('F700',(#1690,#1693),#1679,.T.);
#1695=CARTESIAN_POINT('',(-42.9,0.,0.));
#1696=DIRECTION('',(-1.,0.,0.));
#1697=DIRECTION('',(0.,0.,1.));
#1698=AXIS2_PLACEMENT_3D('',#1695,#1696,#1697);
#1699=PLANE('',#1698);
#1700=CARTESIAN_POINT('',(-42.9,0.,0.));
#1701=DIRECTION('',(-1.,0.,0.));
#1702=DIRECTION('',(0.,0.,1.));
#1703=AXIS2_PLACEMENT_3D('',#1700,#1701,#1702);
#1704=CIRCLE('',#1703,12.5);
#1705=CARTESIAN_POINT('',(-42.9,0.,12.5));
#1706=VERTEX_POINT('',#1705);
#1707=EDGE_CURVE('E351',#1706,#1706,#1704,.T.);
#1708=ORIENTED_EDGE('',*,*,#1707,.F.);
#1709=EDGE_LOOP('',(#1708));
#1710=FACE_BOUND('',#1709,.T.);
#1711=ORIENTED_EDGE('',*,*,#1687,.T.);
#1712=EDGE_LOOP('',(#1711));
#1713=FACE_BOUND('',#1712,.T.);
#1714=ADVANCED_FACE('F1181',(#1710,#1713),#1699,.F.);
#1715=CARTESIAN_POINT('',(-45.9,0.,0.));
#1716=DIRECTION('',(1.,0.,0.));
#1717=DIRECTION('',(0.,0.,-1.));
#1718=AXIS2_PLACEMENT_3D('',#1715,#1716,#1717);
#1719=CYLINDRICAL_SURFACE('',#1718,12.5);
#1720=CARTESIAN_POINT('',(-44.9,0.,0.));
#1721=DIRECTION('',(-1.,0.,0.));
#1722=DIRECTION('',(0.,0.,1.));
#1723=AXIS2_PLACEMENT_3D('',#1720,#1721,#1722);
#1724=CIRCLE('',#1723,12.5);
#1725=CARTESIAN_POINT('',(-44.9,0.,12.5));
#1726=VERTEX_POINT('',#1725);
#1727=EDGE_CURVE('E656',#1726,#1726,#1724,.F.);
#1728=ORIENTED_EDGE('',*,*,#1727,.T.);
#1729=EDGE_LOOP('',(#1728));
#1730=FACE_BOUND('',#1729,.T.);
#1731=ORIENTED_EDGE('',*,*,#1707,.T.);
#1732=EDGE_LOOP('',(#1731));
#1733=FACE_BOUND('',#1732,.T.);
#1734=ADVANCED_FACE('F1187',(#1730,#1733),#1719,.T.);
#1735=CARTESIAN_POINT('',(-45.9,0.,0.));
#1736=DIRECTION('',(-1.,0.,0.));
#1737=DIRECTION('',(0.,0.,1.));
#1738=AXIS2_PLACEMENT_3D('',#1735,#1736,#1737);
#1739=PLANE('',#1738);
#1740=CARTESIAN_POINT('',(-45.9,0.,0.));
#1741=DIRECTION('',(-1.,0.,0.));
#1742=DIRECTION('',(0.,0.,1.));
#1743=AXIS2_PLACEMENT_3D('',#1740,#1741,#1742);
#1744=CIRCLE('',#1743,11.5);
#1745=CARTESIAN_POINT('',(-45.9,0.,11.5));
#1746=VERTEX_POINT('',#1745);
#1747=EDGE_CURVE('E653',#1746,#1746,#1744,.T.);
#1748=ORIENTED_EDGE('',*,*,#1747,.T.);
#1749=EDGE_LOOP('',(#1748));
#1750=FACE_BOUND('',#1749,.T.);
#1751=ADVANCED_FACE('F1197',(#1750),#1739,.T.);
#1752=CARTESIAN_POINT('',(-45.9,0.,0.));
#1753=DIRECTION('',(1.,0.,0.));
#1754=DIRECTION('',(0.,0.,-1.));
#1755=AXIS2_PLACEMENT_3D('',#1752,#1753,#1754);
#1756=CONICAL_SURFACE('',#1755,11.5,0.785398163397443);
#1757=ORIENTED_EDGE('',*,*,#1727,.F.);
#1758=EDGE_LOOP('',(#1757));
#1759=FACE_BOUND('',#1758,.T.);
#1760=ORIENTED_EDGE('',*,*,#1747,.F.);
#1761=EDGE_LOOP('',(#1760));
#1762=FACE_BOUND('',#1761,.T.);
#1763=ADVANCED_FACE('F1202',(#1759,#1762),#1756,.T.);
#1764=CARTESIAN_POINT('',(-30.8,2.93956566887308,11.2565251102846));
#1765=DIRECTION('',(0.,0.995439288208359,0.0953971880677595));
#1766=DIRECTION('',(0.,-0.0953971880677595,0.995439288208359));
#1767=AXIS2_PLACEMENT_3D('',#1764,#1765,#1766);
#1768=PLANE('',#1767);
#1769=DIRECTION('',(0.,-0.0953971880677595,0.995439288208359));
#1770=VECTOR('',#1769,1.);
#1771=CARTESIAN_POINT('',(-30.8,2.93956566887308,11.2565251102846));
#1772=LINE('',#1771,#1770);
#1773=CARTESIAN_POINT('',(-30.8,2.93956566887308,11.2565251102846));
#1774=VERTEX_POINT('',#1773);
#1775=EDGE_CURVE('E44',#1774,#1612,#1772,.T.);
#1776=ORIENTED_EDGE('',*,*,#1775,.F.);
#1777=DIRECTION('',(1.,0.,0.));
#1778=VECTOR('',#1777,1.);
#1779=CARTESIAN_POINT('',(-30.8,2.93956566887308,11.2565251102846));
#1780=LINE('',#1779,#1778);
#1781=CARTESIAN_POINT('',(-15.8,2.93956566887308,11.2565251102846));
#1782=VERTEX_POINT('',#1781);
#1783=EDGE_CURVE('E336',#1774,#1782,#1780,.T.);
#1784=ORIENTED_EDGE('',*,*,#1783,.T.);
#1785=EDGE_CURVE('E329',#1782,#1538,#1575,.T.);
#1786=ORIENTED_EDGE('',*,*,#1785,.T.);
#1787=ORIENTED_EDGE('',*,*,#1576,.T.);
#1788=ORIENTED_EDGE('',*,*,#1619,.F.);
#1789=EDGE_LOOP('',(#1776,#1784,#1786,#1787,#1788));
#1790=FACE_BOUND('',#1789,.T.);
#1791=ADVANCED_FACE('F674',(#1790),#1768,.F.);
#1792=CARTESIAN_POINT('',(-30.8,-5.69478846036176,17.4933476057425));
#1793=DIRECTION('',(0.,-0.995439288208359,-0.0953971880677592));
#1794=DIRECTION('',(0.,0.0953971880677592,-0.995439288208359));
#1795=AXIS2_PLACEMENT_3D('',#1792,#1793,#1794);
#1796=PLANE('',#1795);
#1797=ORIENTED_EDGE('',*,*,#1583,.T.);
#1798=CARTESIAN_POINT('',(-15.8,-5.0239486367938,10.4933476057425));
#1799=VERTEX_POINT('',#1798);
#1800=EDGE_CURVE('E318',#1540,#1799,#1582,.T.);
#1801=ORIENTED_EDGE('',*,*,#1800,.T.);
#1802=DIRECTION('',(1.,0.,0.));
#1803=VECTOR('',#1802,1.);
#1804=CARTESIAN_POINT('',(-30.8,-5.0239486367938,10.4933476057425));
#1805=LINE('',#1804,#1803);
#1806=CARTESIAN_POINT('',(-30.8,-5.0239486367938,10.4933476057425));
#1807=VERTEX_POINT('',#1806);
#1808=EDGE_CURVE('E322',#1807,#1799,#1805,.T.);
#1809=ORIENTED_EDGE('',*,*,#1808,.F.);
#1810=DIRECTION('',(0.,0.0953971880677592,-0.995439288208359));
#1811=VECTOR('',#1810,1.);
#1812=CARTESIAN_POINT('',(-30.8,-5.69478846036176,17.4933476057425));
#1813=LINE('',#1812,#1811);
#1814=EDGE_CURVE('E342',#1610,#1807,#1813,.T.);
#1815=ORIENTED_EDGE('',*,*,#1814,.F.);
#1816=ORIENTED_EDGE('',*,*,#1626,.F.);
#1817=EDGE_LOOP('',(#1797,#1801,#1809,#1815,#1816));
#1818=FACE_BOUND('',#1817,.T.);
#1819=ADVANCED_FACE('F320',(#1818),#1796,.F.);
#1820=CARTESIAN_POINT('',(-30.8,2.93956566887308,11.2565251102846));
#1821=DIRECTION('',(-1.,0.,0.));
#1822=DIRECTION('',(0.,0.,1.));
#1823=AXIS2_PLACEMENT_3D('',#1820,#1821,#1822);
#1824=PLANE('',#1823);
#1825=ORIENTED_EDGE('',*,*,#1814,.T.);
#1826=DIRECTION('',(0.,0.995439288208359,0.0953971880677593));
#1827=VECTOR('',#1826,1.);
#1828=CARTESIAN_POINT('',(-30.8,-5.0239486367938,10.4933476057425));
#1829=LINE('',#1828,#1827);
#1830=EDGE_CURVE('E335',#1807,#1774,#1829,.T.);
#1831=ORIENTED_EDGE('',*,*,#1830,.T.);
#1832=ORIENTED_EDGE('',*,*,#1775,.T.);
#1833=ORIENTED_EDGE('',*,*,#1613,.F.);
#1834=EDGE_LOOP('',(#1825,#1831,#1832,#1833));
#1835=FACE_BOUND('',#1834,.T.);
#1836=ADVANCED_FACE('F675',(#1835),#1824,.F.);
#1837=CARTESIAN_POINT('',(-15.8,2.93956566887308,11.2565251102846));
#1838=DIRECTION('',(-1.,0.,0.));
#1839=DIRECTION('',(0.,0.,1.));
#1840=AXIS2_PLACEMENT_3D('',#1837,#1838,#1839);
#1841=PLANE('',#1840);
#1842=ORIENTED_EDGE('',*,*,#1548,.T.);
#1843=ORIENTED_EDGE('',*,*,#1785,.F.);
#1844=DIRECTION('',(0.,0.995439288208359,0.0953971880677593));
#1845=VECTOR('',#1844,1.);
#1846=CARTESIAN_POINT('',(-15.8,-5.0239486367938,10.4933476057425));
#1847=LINE('',#1846,#1845);
#1848=EDGE_CURVE('E334',#1799,#1782,#1847,.T.);
#1849=ORIENTED_EDGE('',*,*,#1848,.F.);
#1850=ORIENTED_EDGE('',*,*,#1800,.F.);
#1851=EDGE_LOOP('',(#1842,#1843,#1849,#1850));
#1852=FACE_BOUND('',#1851,.T.);
#1853=ADVANCED_FACE('F339',(#1852),#1841,.T.);
#1854=CARTESIAN_POINT('',(-30.8,-5.0239486367938,10.4933476057425));
#1855=DIRECTION('',(0.,0.0953971880677593,-0.995439288208359));
#1856=DIRECTION('',(0.,0.995439288208359,0.0953971880677593));
#1857=AXIS2_PLACEMENT_3D('',#1854,#1855,#1856);
#1858=PLANE('',#1857);
#1859=ORIENTED_EDGE('',*,*,#1848,.T.);
#1860=ORIENTED_EDGE('',*,*,#1783,.F.);
#1861=ORIENTED_EDGE('',*,*,#1830,.F.);
#1862=ORIENTED_EDGE('',*,*,#1808,.T.);
#1863=EDGE_LOOP('',(#1859,#1860,#1861,#1862));
#1864=FACE_BOUND('',#1863,.T.);
#1865=ADVANCED_FACE('F333',(#1864),#1858,.F.);
#1866=CLOSED_SHELL('',(#46,#74,#102,#130,#453,#485,#507,#529,#551,#573,#595,#617,#639,#661,#683,
#708,#733,#751,#776,#801,#819,#844,#869,#887,#912,#937,#955,#980,#1005,#1023,#1048,#1073,#1091,
#1116,#1141,#1159,#1184,#1209,#1227,#1252,#1277,#1295,#1320,#1345,#1363,#1383,#1434,#1454,#1474,
#1494,#1514,#1526,#1555,#1587,#1630,#1650,#1662,#1674,#1694,#1714,#1734,#1751,#1763,#1791,#1819,
#1836,#1853,#1865));
#1867=MANIFOLD_SOLID_BREP('B2',#1866);
#1868=ADVANCED_BREP_SHAPE_REPRESENTATION('',(#18,#1867),#14);
#1869=SHAPE_DEFINITION_REPRESENTATION(#9,#1868);
ENDSEC;
END-ISO-10303-21;
